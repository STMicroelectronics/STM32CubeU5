<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LPBAM_DAC_OPAMP_SigAmpli.ewp</path>
  </project>
  <batchBuild />
</workspace>
