# Keil uVision project LPBAM_I2C_TransmitReceive.uvprojx, settings and files
target LPBAM_I2C_TransmitReceive (6140001::V6.14.1::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: LPBAM_I2C_TransmitReceive +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../LPBAM/Master;../Core/Inc;../LPBAM/Slave;../../../../../../Utilities/lpbam;../../../../../../Utilities/lpbam/STM32U5;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U5xx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x28000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Application/User/LPBAM/Master
    ../LPBAM/Master/: lpbam_master_reloadseq_config.c lpbam_master_config.c lpbam_master_reloadseq_build.c
  group Application/User/LPBAM/Slave
    ../LPBAM/Slave/: lpbam_slave_reloadseq_config.c lpbam_slave_config.c lpbam_slave_reloadseq_build.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_ramcfg.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Utilities
    ../../../../../../Utilities/lpbam/: stm32_adv_lpbam_common.c stm32_lpbam_common.c stm32_adv_lpbam_i2c.c stm32_lpbam_i2c.c
    ../../../../../../Utilities/lpbam/STM32U5/: stm32_ll_lpbam.c
software components: CMSIS:CORE 4.3.0
