# IAR project LPBAM_I2C_TransmitReceive.ewp, settings and files
configuration LPBAM_I2C_TransmitReceive (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../LPBAM/Master; ../Core/Inc; ../LPBAM/Slave; ../../../../../../Utilities/lpbam; ../../../../../../Utilities/lpbam/STM32U5; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPBAM_I2C_TransmitReceive.hex
  ILINK.IlinkOutputFile: LPBAM_I2C_TransmitReceive.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Application/User/LPBAM/Master
    ../LPBAM/Master/: lpbam_master_reloadseq_config.c lpbam_master_config.c lpbam_master_reloadseq_build.c
  group Application/User/LPBAM/Slave
    ../LPBAM/Slave/: lpbam_slave_reloadseq_config.c lpbam_slave_config.c lpbam_slave_reloadseq_build.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_ramcfg.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Utilities
    ../../../../../../Utilities/lpbam/: stm32_adv_lpbam_common.c stm32_lpbam_common.c stm32_adv_lpbam_i2c.c stm32_lpbam_i2c.c
    ../../../../../../Utilities/lpbam/STM32U5/: stm32_ll_lpbam.c
