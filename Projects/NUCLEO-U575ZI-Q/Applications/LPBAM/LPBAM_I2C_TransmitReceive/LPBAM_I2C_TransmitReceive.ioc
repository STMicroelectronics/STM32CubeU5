# file: LPBAM_I2C_TransmitReceive.ioc
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CONF1.CORTEX_M33_NS.userName=CORTEX_M33
CONF1.KeepUserPlacement=false
CONF1.Mcu.ContextProject=TrustZoneDisabled
CONF1.Mcu.Family=STM32U5
CONF1.Mcu.IP0=CORTEX_M33_NS
CONF1.Mcu.IP1=ICACHE
CONF1.Mcu.IP2=LPBAM
CONF1.Mcu.IP3=LPBAMQUEUE
CONF1.Mcu.IP4=LPDMA1
CONF1.Mcu.IP5=NVIC
CONF1.Mcu.IP6=PWR
CONF1.Mcu.IP7=RCC
CONF1.Mcu.IP8=SYS
CONF1.Mcu.IPNb=9
CONF1.Mcu.Name=STM32U575ZITxQ
CONF1.Mcu.Package=LQFP144
CONF1.Mcu.Pin0=PE2
CONF1.Mcu.Pin1=PE3
CONF1.Mcu.Pin10=PF2
CONF1.Mcu.Pin100=PG15
CONF1.Mcu.Pin101=PB3 (JTDO/TRACESWO)
CONF1.Mcu.Pin102=PB4 (NJTRST)
CONF1.Mcu.Pin103=PB5
CONF1.Mcu.Pin104=PB6
CONF1.Mcu.Pin105=PB7
CONF1.Mcu.Pin106=PH3-BOOT0
CONF1.Mcu.Pin107=PB8
CONF1.Mcu.Pin108=PB9
CONF1.Mcu.Pin109=PE0
CONF1.Mcu.Pin11=PF3
CONF1.Mcu.Pin110=PE1
CONF1.Mcu.Pin111=VP_ICACHE_VS_ICACHE
CONF1.Mcu.Pin112=VP_LPBAMQUEUE_VS_QUEUE
CONF1.Mcu.Pin113=VP_LPDMA1_VS_LPDMACH0
CONF1.Mcu.Pin114=VP_PWR_VS_DBSignals
CONF1.Mcu.Pin115=VP_PWR_VS_SECSignals
CONF1.Mcu.Pin116=VP_PWR_VS_LPOM
CONF1.Mcu.Pin117=VP_SYS_VS_Systick
CONF1.Mcu.Pin118=VP_LPBAM_VS_SIG1
CONF1.Mcu.Pin119=VP_LPBAM_VS_SIG2
CONF1.Mcu.Pin12=PF4
CONF1.Mcu.Pin120=VP_LPBAM_VS_SIG4
CONF1.Mcu.Pin121=VP_LPBAM_VS_SIGPW
CONF1.Mcu.Pin122=VP_LPBAM_VS_SIGPWOPT
CONF1.Mcu.Pin13=PF5
CONF1.Mcu.Pin14=PF6
CONF1.Mcu.Pin15=PF7
CONF1.Mcu.Pin16=PF8
CONF1.Mcu.Pin17=PF9
CONF1.Mcu.Pin18=PF10
CONF1.Mcu.Pin19=PH0-OSC_IN (PH0)
CONF1.Mcu.Pin2=PE4
CONF1.Mcu.Pin20=PH1-OSC_OUT (PH1)
CONF1.Mcu.Pin21=PC0
CONF1.Mcu.Pin22=PC1
CONF1.Mcu.Pin23=PC2
CONF1.Mcu.Pin24=PC3
CONF1.Mcu.Pin25=PA0
CONF1.Mcu.Pin26=PA1
CONF1.Mcu.Pin27=PA2
CONF1.Mcu.Pin28=PA3
CONF1.Mcu.Pin29=PA4
CONF1.Mcu.Pin3=PE5
CONF1.Mcu.Pin30=PA5
CONF1.Mcu.Pin31=PA6
CONF1.Mcu.Pin32=PA7
CONF1.Mcu.Pin33=PB0
CONF1.Mcu.Pin34=PB1
CONF1.Mcu.Pin35=PB2
CONF1.Mcu.Pin36=PF11
CONF1.Mcu.Pin37=PF12
CONF1.Mcu.Pin38=PF13
CONF1.Mcu.Pin39=PF14
CONF1.Mcu.Pin4=PE6
CONF1.Mcu.Pin40=PF15
CONF1.Mcu.Pin41=PG0
CONF1.Mcu.Pin42=PG1
CONF1.Mcu.Pin43=PE7
CONF1.Mcu.Pin44=PE8
CONF1.Mcu.Pin45=PE9
CONF1.Mcu.Pin46=PE10
CONF1.Mcu.Pin47=PE11
CONF1.Mcu.Pin48=PE12
CONF1.Mcu.Pin49=PE13
CONF1.Mcu.Pin5=PC13
CONF1.Mcu.Pin50=PE14
CONF1.Mcu.Pin51=PE15
CONF1.Mcu.Pin52=PB10
CONF1.Mcu.Pin53=PB11
CONF1.Mcu.Pin54=PB13
CONF1.Mcu.Pin55=PB14
CONF1.Mcu.Pin56=PB15
CONF1.Mcu.Pin57=PD8
CONF1.Mcu.Pin58=PD9
CONF1.Mcu.Pin59=PD10
CONF1.Mcu.Pin6=PC14-OSC32_IN (PC14)
CONF1.Mcu.Pin60=PD11
CONF1.Mcu.Pin61=PD12
CONF1.Mcu.Pin62=PD13
CONF1.Mcu.Pin63=PD14
CONF1.Mcu.Pin64=PD15
CONF1.Mcu.Pin65=PG2
CONF1.Mcu.Pin66=PG3
CONF1.Mcu.Pin67=PG4
CONF1.Mcu.Pin68=PG5
CONF1.Mcu.Pin69=PG6
CONF1.Mcu.Pin7=PC15-OSC32_OUT (PC15)
CONF1.Mcu.Pin70=PG7
CONF1.Mcu.Pin71=PG8
CONF1.Mcu.Pin72=PC6
CONF1.Mcu.Pin73=PC7
CONF1.Mcu.Pin74=PC8
CONF1.Mcu.Pin75=PC9
CONF1.Mcu.Pin76=PA8
CONF1.Mcu.Pin77=PA9
CONF1.Mcu.Pin78=PA10
CONF1.Mcu.Pin79=PA11
CONF1.Mcu.Pin8=PF0
CONF1.Mcu.Pin80=PA12
CONF1.Mcu.Pin81=PA13 (JTMS/SWDIO)
CONF1.Mcu.Pin82=PA14 (JTCK/SWCLK)
CONF1.Mcu.Pin83=PA15 (JTDI)
CONF1.Mcu.Pin84=PC10
CONF1.Mcu.Pin85=PC11
CONF1.Mcu.Pin86=PC12
CONF1.Mcu.Pin87=PD0
CONF1.Mcu.Pin88=PD1
CONF1.Mcu.Pin89=PD2
CONF1.Mcu.Pin9=PF1
CONF1.Mcu.Pin90=PD3
CONF1.Mcu.Pin91=PD4
CONF1.Mcu.Pin92=PD5
CONF1.Mcu.Pin93=PD6
CONF1.Mcu.Pin94=PD7
CONF1.Mcu.Pin95=PG9
CONF1.Mcu.Pin96=PG10
CONF1.Mcu.Pin97=PG12
CONF1.Mcu.Pin98=PG13
CONF1.Mcu.Pin99=PG14
CONF1.Mcu.PinsNb=123
CONF1.Mcu.ThirdPartyNb=0
CONF1.Mcu.UserName=STM32U575ZITxQ
CONF1.NVIC.BusFault_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.DebugMonitor_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.ForceEnableDMAVector=true
CONF1.NVIC.HardFault_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.LPDMA1_Channel0_IRQn=true\:0\:0\:false\:false\:true\:true\:true\:true
CONF1.NVIC.MemoryManagement_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.NonMaskableInt_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.PendSV_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
CONF1.NVIC.SVCall_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.SysTick_IRQn=true\:15\:0\:false\:false\:true\:false\:true\:false
CONF1.NVIC.UsageFault_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.PA0.Signal=GPIO_Analog
CONF1.PA1.Signal=GPIO_Analog
CONF1.PA10.Signal=GPIO_Analog
CONF1.PA11.Signal=GPIO_Analog
CONF1.PA12.Signal=GPIO_Analog
CONF1.PA13\ (JTMS/SWDIO).Signal=GPIO_Analog
CONF1.PA14\ (JTCK/SWCLK).Signal=GPIO_Analog
CONF1.PA15\ (JTDI).Signal=GPIO_Analog
CONF1.PA2.Signal=GPIO_Analog
CONF1.PA3.Signal=GPIO_Analog
CONF1.PA4.Signal=GPIO_Analog
CONF1.PA5.Signal=GPIO_Analog
CONF1.PA6.Signal=GPIO_Analog
CONF1.PA7.Signal=GPIO_Analog
CONF1.PA8.Signal=GPIO_Analog
CONF1.PA9.Signal=GPIO_Analog
CONF1.PB0.Signal=GPIO_Analog
CONF1.PB1.Signal=GPIO_Analog
CONF1.PB10.Signal=GPIO_Analog
CONF1.PB11.Signal=GPIO_Analog
CONF1.PB13.Signal=GPIO_Analog
CONF1.PB14.Signal=GPIO_Analog
CONF1.PB15.Signal=GPIO_Analog
CONF1.PB2.Signal=GPIO_Analog
CONF1.PB3\ (JTDO/TRACESWO).Signal=GPIO_Analog
CONF1.PB4\ (NJTRST).Signal=GPIO_Analog
CONF1.PB5.Signal=GPIO_Analog
CONF1.PB6.Signal=GPIO_Analog
CONF1.PB7.Signal=GPIO_Analog
CONF1.PB8.Signal=GPIO_Analog
CONF1.PB9.Signal=GPIO_Analog
CONF1.PC0.Signal=GPIO_Analog
CONF1.PC1.Signal=GPIO_Analog
CONF1.PC10.Signal=GPIO_Analog
CONF1.PC11.Signal=GPIO_Analog
CONF1.PC12.Signal=GPIO_Analog
CONF1.PC13.Signal=GPIO_Analog
CONF1.PC14-OSC32_IN\ (PC14).Signal=GPIO_Analog
CONF1.PC15-OSC32_OUT\ (PC15).Signal=GPIO_Analog
CONF1.PC2.Signal=GPIO_Analog
CONF1.PC3.Signal=GPIO_Analog
CONF1.PC6.Signal=GPIO_Analog
CONF1.PC7.Signal=GPIO_Analog
CONF1.PC8.Signal=GPIO_Analog
CONF1.PC9.Signal=GPIO_Analog
CONF1.PD0.Signal=GPIO_Analog
CONF1.PD1.Signal=GPIO_Analog
CONF1.PD10.Signal=GPIO_Analog
CONF1.PD11.Signal=GPIO_Analog
CONF1.PD12.Signal=GPIO_Analog
CONF1.PD13.Signal=GPIO_Analog
CONF1.PD14.Signal=GPIO_Analog
CONF1.PD15.Signal=GPIO_Analog
CONF1.PD2.Signal=GPIO_Analog
CONF1.PD3.Signal=GPIO_Analog
CONF1.PD4.Signal=GPIO_Analog
CONF1.PD5.Signal=GPIO_Analog
CONF1.PD6.Signal=GPIO_Analog
CONF1.PD7.Signal=GPIO_Analog
CONF1.PD8.Signal=GPIO_Analog
CONF1.PD9.Signal=GPIO_Analog
CONF1.PE0.Signal=GPIO_Analog
CONF1.PE1.Signal=GPIO_Analog
CONF1.PE10.Signal=GPIO_Analog
CONF1.PE11.Signal=GPIO_Analog
CONF1.PE12.Signal=GPIO_Analog
CONF1.PE13.Signal=GPIO_Analog
CONF1.PE14.Signal=GPIO_Analog
CONF1.PE15.Signal=GPIO_Analog
CONF1.PE2.Signal=GPIO_Analog
CONF1.PE3.Signal=GPIO_Analog
CONF1.PE4.Signal=GPIO_Analog
CONF1.PE5.Signal=GPIO_Analog
CONF1.PE6.Signal=GPIO_Analog
CONF1.PE7.Signal=GPIO_Analog
CONF1.PE8.Signal=GPIO_Analog
CONF1.PE9.Signal=GPIO_Analog
CONF1.PF0.Signal=GPIO_Analog
CONF1.PF1.Signal=GPIO_Analog
CONF1.PF10.Signal=GPIO_Analog
CONF1.PF11.Signal=GPIO_Analog
CONF1.PF12.Signal=GPIO_Analog
CONF1.PF13.Signal=GPIO_Analog
CONF1.PF14.Signal=GPIO_Analog
CONF1.PF15.Signal=GPIO_Analog
CONF1.PF2.Signal=GPIO_Analog
CONF1.PF3.Signal=GPIO_Analog
CONF1.PF4.Signal=GPIO_Analog
CONF1.PF5.Signal=GPIO_Analog
CONF1.PF6.Signal=GPIO_Analog
CONF1.PF7.Signal=GPIO_Analog
CONF1.PF8.Signal=GPIO_Analog
CONF1.PF9.Signal=GPIO_Analog
CONF1.PG0.Signal=GPIO_Analog
CONF1.PG1.Signal=GPIO_Analog
CONF1.PG10.Signal=GPIO_Analog
CONF1.PG12.Signal=GPIO_Analog
CONF1.PG13.Signal=GPIO_Analog
CONF1.PG14.Signal=GPIO_Analog
CONF1.PG15.Signal=GPIO_Analog
CONF1.PG2.Signal=GPIO_Analog
CONF1.PG3.Signal=GPIO_Analog
CONF1.PG4.Signal=GPIO_Analog
CONF1.PG5.Signal=GPIO_Analog
CONF1.PG6.Signal=GPIO_Analog
CONF1.PG7.Signal=GPIO_Analog
CONF1.PG8.Signal=GPIO_Analog
CONF1.PG9.Signal=GPIO_Analog
CONF1.PH0-OSC_IN\ (PH0).Signal=GPIO_Analog
CONF1.PH1-OSC_OUT\ (PH1).Signal=GPIO_Analog
CONF1.PH3-BOOT0.Signal=GPIO_Analog
CONF1.PWR.PowerMode=PWR_SMPS_SUPPLY
CONF1.RCC.ADCFreq_Value=16000000
CONF1.RCC.ADF1Freq_Value=160000000
CONF1.RCC.AHBFreq_Value=160000000
CONF1.RCC.APB1Freq_Value=160000000
CONF1.RCC.APB1TimFreq_Value=160000000
CONF1.RCC.APB2Freq_Value=160000000
CONF1.RCC.APB2TimFreq_Value=160000000
CONF1.RCC.APB3Freq_Value=160000000
CONF1.RCC.CK48Freq_Value=48000000
CONF1.RCC.CRSFreq_Value=48000000
CONF1.RCC.CortexFreq_Value=160000000
CONF1.RCC.DACCLockSelectionVirtual=RCC_DAC1CLKSOURCE_LSI
CONF1.RCC.DACCLockSelectionVirtualString=RCC_DAC1CLKSOURCE_LSI
CONF1.RCC.DACFreq_Value=32000
CONF1.RCC.EPOD_VALUE=4000000
CONF1.RCC.FCLKCortexFreq_Value=160000000
CONF1.RCC.FDCANFreq_Value=160000000
CONF1.RCC.FamilyName=M
CONF1.RCC.HCLKFreq_Value=160000000
CONF1.RCC.HSE_VALUE=16000000
CONF1.RCC.HSI48_VALUE=48000000
CONF1.RCC.HSI_VALUE=16000000
CONF1.RCC.I2C1Freq_Value=160000000
CONF1.RCC.I2C2Freq_Value=160000000
CONF1.RCC.I2C3Freq_Value=160000000
CONF1.RCC.I2C4Freq_Value=160000000
CONF1.RCC.LPTIM2Freq_Value=160000000
CONF1.RCC.LPUART1Freq_Value=160000000
CONF1.RCC.LSCOPinFreq_Value=32000
CONF1.RCC.LSE_VALUE=32768
CONF1.RCC.LSIDIV_VALUE=32000
CONF1.RCC.LSI_VALUE=32000
CONF1.RCC.MCO1PinFreq_Value=160000000
CONF1.RCC.MDF1Freq_Value=160000000
CONF1.RCC.MSI_VALUE=4000000
CONF1.RCC.OCTOSPIMFreq_Value=160000000
CONF1.RCC.PLL2PoutputFreq_Value=258000000
CONF1.RCC.PLL2QoutputFreq_Value=258000000
CONF1.RCC.PLL2RoutputFreq_Value=258000000
CONF1.RCC.PLL3PoutputFreq_Value=258000000
CONF1.RCC.PLL3QoutputFreq_Value=258000000
CONF1.RCC.PLL3RoutputFreq_Value=258000000
CONF1.RCC.PLLN=80
CONF1.RCC.PLLPoutputFreq_Value=160000000
CONF1.RCC.PLLQoutputFreq_Value=160000000
CONF1.RCC.PLLRCLKFreq_Value=160000000
CONF1.RCC.RNGFreq_Value=48000000
CONF1.RCC.SAI1Freq_Value=258000000
CONF1.RCC.SAI2Freq_Value=258000000
CONF1.RCC.SDMMCFreq_Value=160000000
CONF1.RCC.SPI1Freq_Value=160000000
CONF1.RCC.SPI2Freq_Value=160000000
CONF1.RCC.SPI3Freq_Value=160000000
CONF1.RCC.SYSCLKFreq_VALUE=160000000
CONF1.RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
CONF1.RCC.UART4Freq_Value=160000000
CONF1.RCC.UART5Freq_Value=160000000
CONF1.RCC.USART1Freq_Value=160000000
CONF1.RCC.USART2Freq_Value=160000000
CONF1.RCC.USART3Freq_Value=160000000
CONF1.RCC.USBFreq_Value=48000000
CONF1.RCC.VCOInput2Freq_Value=4000000
CONF1.RCC.VCOInput3Freq_Value=4000000
CONF1.RCC.VCOInputFreq_Value=4000000
CONF1.RCC.VCOOutputFreq_Value=320000000
CONF1.RCC.VCOPLL2OutputFreq_Value=516000000
CONF1.RCC.VCOPLL3OutputFreq_Value=516000000
CONF1.ScenarioCount=0
CONF1.VP_ICACHE_VS_ICACHE.Mode=DirectMappedCache
CONF1.VP_ICACHE_VS_ICACHE.Signal=ICACHE_VS_ICACHE
CONF1.VP_LPBAMQUEUE_VS_QUEUE.Mode=QUEUEMODE
CONF1.VP_LPBAMQUEUE_VS_QUEUE.Signal=LPBAMQUEUE_VS_QUEUE
CONF1.VP_LPBAM_VS_SIG1.Mode=SmartRun
CONF1.VP_LPBAM_VS_SIG1.Signal=LPBAM_VS_SIG1
CONF1.VP_LPBAM_VS_SIG2.Signal=LPBAM_VS_SIG2
CONF1.VP_LPBAM_VS_SIG4.Mode=LPDMA1
CONF1.VP_LPBAM_VS_SIG4.Signal=LPBAM_VS_SIG4
CONF1.VP_LPBAM_VS_SIGPW.Signal=LPBAM_VS_SIGPW
CONF1.VP_LPBAM_VS_SIGPWOPT.Signal=LPBAM_VS_SIGPWOPT
CONF1.VP_LPDMA1_VS_LPDMACH0.Mode=LINKEDLIST_LPDMACH0
CONF1.VP_LPDMA1_VS_LPDMACH0.Signal=LPDMA1_VS_LPDMACH0
CONF1.VP_PWR_VS_DBSignals.Mode=DisableDeadBatterySignals
CONF1.VP_PWR_VS_DBSignals.Signal=PWR_VS_DBSignals
CONF1.VP_PWR_VS_LPOM.Mode=PowerOptimisation
CONF1.VP_PWR_VS_LPOM.Signal=PWR_VS_LPOM
CONF1.VP_PWR_VS_SECSignals.Mode=Security/Privilege
CONF1.VP_PWR_VS_SECSignals.Signal=PWR_VS_SECSignals
CONF1.VP_SYS_VS_Systick.Mode=SysTick
CONF1.VP_SYS_VS_Systick.Signal=SYS_VS_Systick
CONF2.CORTEX_M33_NS.userName=CORTEX_M33
CONF2.ConfName=Master
CONF2.File.Version=6
CONF2.GPIO.groupedBy=Group By Peripherals
CONF2.I2C3.AutonomousMode=AUTONOMOUS_MODE_ENABLE
CONF2.I2C3.I2C_Fall_Time=20
CONF2.I2C3.I2C_Rise_Time=20
CONF2.I2C3.Interrupt1=I2C_IT_ERRI
CONF2.I2C3.OwnAddress=LPBAM_I2C3_ADDRESS
CONF2.I2C3.Timing=0x00100D14
CONF2.I2C3.TriggerSelection=I2C_GRP2_RTC_ALRA_TRG
CONF2.KeepUserPlacement=false
CONF2.Mcu.CPN=STM32U575ZIT6Q
CONF2.Mcu.ContextProject=TrustZoneDisabled
CONF2.Mcu.Family=STM32U5
CONF2.Mcu.IP0=CORTEX_M33_NS
CONF2.Mcu.IP1=I2C3
CONF2.Mcu.IP2=LPBAM
CONF2.Mcu.IP3=LPBAMQUEUE
CONF2.Mcu.IP4=NVIC
CONF2.Mcu.IP5=PWR
CONF2.Mcu.IP6=RCC
CONF2.Mcu.IP7=RTC
CONF2.Mcu.IP8=SYS
CONF2.Mcu.IPNb=9
CONF2.Mcu.Name=STM32U575ZITxQ
CONF2.Mcu.Package=LQFP144
CONF2.Mcu.Pin0=PC0
CONF2.Mcu.Pin1=PC1
CONF2.Mcu.Pin10=VP_LPBAM_VS_SIG1
CONF2.Mcu.Pin11=VP_LPBAM_VS_SIG2
CONF2.Mcu.Pin12=VP_LPBAM_VS_SIG4
CONF2.Mcu.Pin13=VP_LPBAM_VS_SIGPW
CONF2.Mcu.Pin14=VP_LPBAM_VS_SIGPWOPT
CONF2.Mcu.Pin2=VP_I2C3_VS_I2C_LPBAM
CONF2.Mcu.Pin3=VP_LPBAMQUEUE_VS_QUEUE
CONF2.Mcu.Pin4=VP_PWR_VS_DBSignals
CONF2.Mcu.Pin5=VP_PWR_VS_LPOM
CONF2.Mcu.Pin6=VP_RTC_VS_RTC_Activate
CONF2.Mcu.Pin7=VP_RTC_VS_RTC_Calendar
CONF2.Mcu.Pin8=VP_RTC_VS_RTC_Alarm_A_Intern
CONF2.Mcu.Pin9=VP_SYS_VS_Systick
CONF2.Mcu.PinsNb=15
CONF2.Mcu.ThirdPartyNb=0
CONF2.Mcu.UserConstants=RX_BUFFER1_SIZE,55U;RTC_ASYNCH_PREDIV,0x7F;LPBAM_I2C3_ADDRESS,0x35U;RX_BUFFER2_SIZE,310U;TX_BUFFER1_SIZE,55U;RTC_SYNCH_PREDIV,0x00F9;TX_BUFFER2_SIZE,310U
CONF2.Mcu.UserName=STM32U575ZITxQ
CONF2.MultiConf.NbConfig=3
CONF2.MxCube.Version=6.5.0
CONF2.MxDb.Version=DB.6.0.60
CONF2.NVIC.ForceEnableDMAVector=true
CONF2.NVIC.I2C3_ER_IRQn=true\:0\:0\:false\:false\:true\:true\:true\:true
CONF2.NVIC.I2C3_EV_IRQn=true\:0\:0\:false\:false\:true\:true\:true\:true
CONF2.NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
CONF2.PC0.Mode=I2C
CONF2.PC0.Signal=I2C3_SCL
CONF2.PC1.Mode=I2C
CONF2.PC1.Signal=I2C3_SDA
CONF2.PWR.DMA2DPowerDownInStopMode=PWR_DMA2DRAM_FULL_STOP_RETENTION
CONF2.PWR.Dcache1PowerDownInStopMode=PWR_DCACHE1_FULL_STOP_RETENTION
CONF2.PWR.PKA32RAMPowerDownInStopMode=PWR_PKA32RAM_FULL_STOP_RETENTION
CONF2.PWR.PeriphPowerDownInStopMode=PWR_PERIPHRAM_FULL_STOP_RETENTION
CONF2.PWR.RAM1Page1PowerDownInStopMode=PWR_SRAM1_PAGE1_STOP_RETENTION
CONF2.PWR.RAM1Page2PowerDownInStopMode=PWR_SRAM1_PAGE2_STOP_RETENTION
CONF2.PWR.RAM1Page3PowerDownInStopMode=PWR_SRAM1_PAGE3_STOP_RETENTION
CONF2.PWR.RAM2Page1PowerDownInStopMode=PWR_SRAM2_PAGE1_STOP_RETENTION
CONF2.PWR.RAM2Page2PowerDownInStopMode=PWR_SRAM2_PAGE2_STOP_RETENTION
CONF2.PWR.RAM3Page1PowerDownInStopMode=PWR_SRAM3_PAGE1_STOP_RETENTION
CONF2.PWR.RAM3Page2PowerDownInStopMode=PWR_SRAM3_PAGE2_STOP_RETENTION
CONF2.PWR.RAM3Page3PowerDownInStopMode=PWR_SRAM3_PAGE3_STOP_RETENTION
CONF2.PWR.RAM3Page4PowerDownInStopMode=PWR_SRAM3_PAGE4_STOP_RETENTION
CONF2.PWR.RAM3Page5PowerDownInStopMode=PWR_SRAM3_PAGE5_STOP_RETENTION
CONF2.PWR.RAM3Page6PowerDownInStopMode=PWR_SRAM3_PAGE6_STOP_RETENTION
CONF2.PWR.RAM3Page7PowerDownInStopMode=PWR_SRAM3_PAGE7_STOP_RETENTION
CONF2.PWR.RAM3Page8PowerDownInStopMode=PWR_SRAM3_PAGE8_STOP_RETENTION
CONF2.PinOutPanel.RotationAngle=0
CONF2.RCC.ADCFreq_Value=16000000
CONF2.RCC.ADF1Freq_Value=4000000
CONF2.RCC.AHBFreq_Value=160000000
CONF2.RCC.APB1Freq_Value=160000000
CONF2.RCC.APB1TimFreq_Value=160000000
CONF2.RCC.APB2Freq_Value=160000000
CONF2.RCC.APB2TimFreq_Value=160000000
CONF2.RCC.APB3Freq_Value=160000000
CONF2.RCC.CK48Freq_Value=4000000
CONF2.RCC.CRSFreq_Value=48000000
CONF2.RCC.CortexFreq_Value=160000000
CONF2.RCC.DACCLockSelectionVirtual=RCC_DAC1CLKSOURCE_LSI
CONF2.RCC.DACCLockSelectionVirtualString=RCC_DAC1CLKSOURCE_LSI
CONF2.RCC.DACFreq_Value=32000
CONF2.RCC.EPOD_VALUE=4000000
CONF2.RCC.FCLKCortexFreq_Value=160000000
CONF2.RCC.FDCANFreq_Value=160000000
CONF2.RCC.FamilyName=M
CONF2.RCC.HCLKFreq_Value=160000000
CONF2.RCC.HSE_VALUE=16000000
CONF2.RCC.HSI48_VALUE=48000000
CONF2.RCC.HSI_VALUE=16000000
CONF2.RCC.I2C1Freq_Value=16000000
CONF2.RCC.I2C2Freq_Value=16000000
CONF2.RCC.I2C3CLockSelection=RCC_I2C3CLKSOURCE_MSIK
CONF2.RCC.I2C3Freq_Value=4000000
CONF2.RCC.I2C4Freq_Value=16000000
CONF2.RCC.LPTIM2Freq_Value=16000000
CONF2.RCC.LPUART1Freq_Value=16000000
CONF2.RCC.LSCOPinFreq_Value=32000
CONF2.RCC.LSE_VALUE=32768
CONF2.RCC.LSIDIV_VALUE=32000
CONF2.RCC.LSI_VALUE=32000
CONF2.RCC.MCO1PinFreq_Value=160000000
CONF2.RCC.MDF1Freq_Value=4000000
CONF2.RCC.MSI_VALUE=4000000
CONF2.RCC.OCTOSPIMFreq_Value=4000000
CONF2.RCC.PLL2PoutputFreq_Value=258000000
CONF2.RCC.PLL2QoutputFreq_Value=258000000
CONF2.RCC.PLL2RoutputFreq_Value=258000000
CONF2.RCC.PLL3PoutputFreq_Value=258000000
CONF2.RCC.PLL3QoutputFreq_Value=258000000
CONF2.RCC.PLL3RoutputFreq_Value=258000000
CONF2.RCC.PLLN=80
CONF2.RCC.PLLPoutputFreq_Value=160000000
CONF2.RCC.PLLQoutputFreq_Value=160000000
CONF2.RCC.PLLRCLKFreq_Value=160000000
CONF2.RCC.RNGFreq_Value=16000000
CONF2.RCC.SAI1Freq_Value=16000000
CONF2.RCC.SAI2Freq_Value=16000000
CONF2.RCC.SDMMCFreq_Value=4000000
CONF2.RCC.SPI1Freq_Value=16000000
CONF2.RCC.SPI2Freq_Value=16000000
CONF2.RCC.SPI3Freq_Value=16000000
CONF2.RCC.SYSCLKFreq_VALUE=160000000
CONF2.RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
CONF2.RCC.UART4Freq_Value=16000000
CONF2.RCC.UART5Freq_Value=16000000
CONF2.RCC.USART1Freq_Value=16000000
CONF2.RCC.USART2Freq_Value=16000000
CONF2.RCC.USART3Freq_Value=16000000
CONF2.RCC.USBFreq_Value=4000000
CONF2.RCC.VCOInput2Freq_Value=4000000
CONF2.RCC.VCOInput3Freq_Value=4000000
CONF2.RCC.VCOInputFreq_Value=4000000
CONF2.RCC.VCOOutputFreq_Value=320000000
CONF2.RCC.VCOPLL2OutputFreq_Value=516000000
CONF2.RCC.VCOPLL3OutputFreq_Value=516000000
CONF2.RTC.Alarm-Alarm\ A=RTC_ALARM_A
CONF2.RTC.AlarmDateWeekDaySel-Alarm\ A=RTC_ALARMDATEWEEKDAYSEL_WEEKDAY
CONF2.RTC.AlarmSubSecondMask-Alarm\ A=RTC_ALARMSUBSECONDMASK_NONE
CONF2.RTC.AsynchPrediv=RTC_ASYNCH_PREDIV
CONF2.RTC.BinMode=RTC_BINARY_NONE
CONF2.RTC.Date=24
CONF2.RTC.HourFormat=RTC_HOURFORMAT_12
CONF2.RTC.Hours=2
CONF2.RTC.Hours_A-Alarm\ A=2
CONF2.RTC.Minutes=32
CONF2.RTC.Minutes_A-Alarm\ A=32
CONF2.RTC.Month=RTC_MONTH_FEBRUARY
CONF2.RTC.Seconds_A-Alarm\ A=5
CONF2.RTC.SynchPrediv=RTC_SYNCH_PREDIV
CONF2.RTC.Year=20
CONF2.S1.Q1.F1.FuncUserName=Master_Transmit_Data_1
CONF2.S1.Q1.F1.FuncVirtualPinList=VP_LPBAMI2C3_VS_MASTERTRANSMIT_DATA
CONF2.S1.Q1.F1.IpInstanceName=LPBAMI2C3
CONF2.S1.Q1.F1.LPBAMI2C3.AM_TriggerState_MTX_DATA=LPBAM_I2C_AUTO_MODE_ENABLE
CONF2.S1.Q1.F1.LPBAMI2C3.AutoModeTriggerState=LPBAM_I2C_AUTO_MODE_ENABLE
CONF2.S1.Q1.F1.LPBAMI2C3.BufferName=aTxBuffer1
CONF2.S1.Q1.F1.LPBAMI2C3.BufferOffset=0
CONF2.S1.Q1.F1.LPBAMI2C3.DevAddress_MTX_DATA=0x35
CONF2.S1.Q1.F1.LPBAMI2C3.NodeLevel_MASTERTRANSMIT_DATA=LPBAM_I2C_MASTERTX_DATAQ_CONFIG_NODE
CONF2.S1.Q1.F1.LPBAMI2C3.QUEUE_NAME=Master_Q
CONF2.S1.Q1.F1.LPBAMI2C3.SequenceNumber_MTX_DATA=2
CONF2.S1.Q1.F1.LPBAMI2C3.Size=55
CONF2.S1.Q1.F1.LPBAMI2C3.Size_MTX_DATA=55
CONF2.S1.Q1.F1.VP_LPBAMI2C3_VS_MASTERTRANSMIT_DATA.Mode=MASTERTRANSMIT_DATA
CONF2.S1.Q1.F1.VP_LPBAMI2C3_VS_MASTERTRANSMIT_DATA.Signal=LPBAMI2C3_VS_MASTERTRANSMIT_DATA
CONF2.S1.Q1.F2.FuncUserName=Master_Receive_Data_1
CONF2.S1.Q1.F2.FuncVirtualPinList=VP_LPBAMI2C3_VS_MASTERRECEIVE_DATA
CONF2.S1.Q1.F2.IpInstanceName=LPBAMI2C3
CONF2.S1.Q1.F2.LPBAMI2C3.AM_TriggerState_MRX_DATA=LPBAM_I2C_AUTO_MODE_ENABLE
CONF2.S1.Q1.F2.LPBAMI2C3.AutoModeTriggerState=LPBAM_I2C_AUTO_MODE_ENABLE
CONF2.S1.Q1.F2.LPBAMI2C3.BufferName=aRxBuffer2
CONF2.S1.Q1.F2.LPBAMI2C3.BufferOffset=0
CONF2.S1.Q1.F2.LPBAMI2C3.DevAddress_MRX_DATA=0x35
CONF2.S1.Q1.F2.LPBAMI2C3.NodeLevel_MASTERRECEIVE_DATA=LPBAM_I2C_MASTERRX_DATAQ_CONFIG_NODE
CONF2.S1.Q1.F2.LPBAMI2C3.QUEUE_NAME=Master_Q
CONF2.S1.Q1.F2.LPBAMI2C3.SequenceNumber_MRX_DATA=2
CONF2.S1.Q1.F2.LPBAMI2C3.Size=310
CONF2.S1.Q1.F2.LPBAMI2C3.Size_MRX_DATA=337
CONF2.S1.Q1.F2.VP_LPBAMI2C3_VS_MASTERRECEIVE_DATA.Mode=MASTERRECEIVE_DATA
CONF2.S1.Q1.F2.VP_LPBAMI2C3_VS_MASTERRECEIVE_DATA.Signal=LPBAMI2C3_VS_MASTERRECEIVE_DATA
CONF2.S1.Q1.FuncCount=2
CONF2.S1.Q1.FuncLastActive=F1
CONF2.S1.Q1.IpInstanceName=LPBAMQUEUE
CONF2.S1.Q1.LPBAMQUEUE.Interrupt1=DMA_IT_DTE
CONF2.S1.Q1.LPBAMQUEUE.Interrupt2=DMA_IT_ULE
CONF2.S1.Q1.LPBAMQUEUE.Interrupt3=DMA_IT_USE
CONF2.S1.Q1.LPBAMQUEUE.Interrupt6=DMA_IT_TO
CONF2.S1.Q1.LPBAMQUEUE.LINKALLOCATEDPORT=DMA_LINK_ALLOCATED_PORT1
CONF2.S1.Q1.LPBAMQUEUE.PRIORITY=DMA_LOW_PRIORITY_HIGH_WEIGHT
CONF2.S1.Q1.QueueCircularity=0
CONF2.S1.Q1.QueueUserName=Master
CONF2.S1.Q1.QueueVirtualPinList=VP_LPBAMQUEUE_VS_QUEUE
CONF2.S1.Q1.VP_LPBAMQUEUE_VS_QUEUE.Mode=QUEUEMODE
CONF2.S1.Q1.VP_LPBAMQUEUE_VS_QUEUE.Signal=LPBAMQUEUE_VS_QUEUE
CONF2.S1.QueueCount=1
CONF2.S1.QueueLastActive=Q1
CONF2.S1.ScenarioName=ReloadSeq
CONF2.ScenarioCount=1
CONF2.VP_I2C3_VS_I2C_LPBAM.Mode=LPBAMSPECIFIC
CONF2.VP_I2C3_VS_I2C_LPBAM.Signal=I2C3_VS_I2C_LPBAM
CONF2.VP_LPBAM_VS_SIG1.Mode=SmartRun
CONF2.VP_LPBAM_VS_SIG1.Signal=LPBAM_VS_SIG1
CONF2.VP_LPBAM_VS_SIG2.Signal=LPBAM_VS_SIG2
CONF2.VP_LPBAM_VS_SIG4.Mode=LPDMA1
CONF2.VP_LPBAM_VS_SIG4.Signal=LPBAM_VS_SIG4
CONF2.VP_LPBAM_VS_SIGPW.Signal=LPBAM_VS_SIGPW
CONF2.VP_LPBAM_VS_SIGPWOPT.Signal=LPBAM_VS_SIGPWOPT
CONF2.VP_PWR_VS_DBSignals.Mode=DisableDeadBatterySignals
CONF2.VP_PWR_VS_DBSignals.Signal=PWR_VS_DBSignals
CONF2.VP_PWR_VS_LPOM.Mode=PowerOptimisation
CONF2.VP_PWR_VS_LPOM.Signal=PWR_VS_LPOM
CONF2.VP_RTC_VS_RTC_Activate.Mode=RTC_Enabled
CONF2.VP_RTC_VS_RTC_Activate.Signal=RTC_VS_RTC_Activate
CONF2.VP_RTC_VS_RTC_Alarm_A_Intern.Mode=Alarm A
CONF2.VP_RTC_VS_RTC_Alarm_A_Intern.Signal=RTC_VS_RTC_Alarm_A_Intern
CONF2.VP_RTC_VS_RTC_Calendar.Mode=RTC_Calendar
CONF2.VP_RTC_VS_RTC_Calendar.Signal=RTC_VS_RTC_Calendar
CONF2.VP_SYS_VS_Systick.Mode=SysTick
CONF2.VP_SYS_VS_Systick.Signal=SYS_VS_Systick
CONF2.board=custom
CONF3.CORTEX_M33_NS.userName=CORTEX_M33
CONF3.ConfName=Slave
CONF3.File.Version=6
CONF3.GPIO.groupedBy=Group By Peripherals
CONF3.I2C3.DualAddressMode=I2C_DUALADDRESS_DISABLE
CONF3.I2C3.GeneralCallMode=I2C_GENERALCALL_DISABLE
CONF3.I2C3.I2C_Fall_Time=20
CONF3.I2C3.I2C_Rise_Time=20
CONF3.I2C3.Interrupt1=I2C_IT_ERRI
CONF3.I2C3.OwnAddress=LPBAM_I2C3_ADDRESS
CONF3.I2C3.Timing=0x00100D14
CONF3.KeepUserPlacement=false
CONF3.Mcu.CPN=STM32U575ZIT6Q
CONF3.Mcu.ContextProject=TrustZoneDisabled
CONF3.Mcu.Family=STM32U5
CONF3.Mcu.IP0=CORTEX_M33_NS
CONF3.Mcu.IP1=I2C3
CONF3.Mcu.IP2=LPBAM
CONF3.Mcu.IP3=LPBAMQUEUE
CONF3.Mcu.IP4=NVIC
CONF3.Mcu.IP5=PWR
CONF3.Mcu.IP6=RCC
CONF3.Mcu.IP7=SYS
CONF3.Mcu.IPNb=8
CONF3.Mcu.Name=STM32U575ZITxQ
CONF3.Mcu.Package=LQFP144
CONF3.Mcu.Pin0=PC0
CONF3.Mcu.Pin1=PC1
CONF3.Mcu.Pin10=VP_LPBAM_VS_SIGPW
CONF3.Mcu.Pin11=VP_LPBAM_VS_SIGPWOPT
CONF3.Mcu.Pin2=VP_I2C3_VS_I2C_LPBAM
CONF3.Mcu.Pin3=VP_LPBAMQUEUE_VS_QUEUE
CONF3.Mcu.Pin4=VP_PWR_VS_DBSignals
CONF3.Mcu.Pin5=VP_PWR_VS_LPOM
CONF3.Mcu.Pin6=VP_SYS_VS_Systick
CONF3.Mcu.Pin7=VP_LPBAM_VS_SIG1
CONF3.Mcu.Pin8=VP_LPBAM_VS_SIG2
CONF3.Mcu.Pin9=VP_LPBAM_VS_SIG4
CONF3.Mcu.PinsNb=12
CONF3.Mcu.ThirdPartyNb=0
CONF3.Mcu.UserConstants=RX_BUFFER1_SIZE,55U;RTC_ASYNCH_PREDIV,0x7F;LPBAM_I2C3_ADDRESS,0x35U;RX_BUFFER2_SIZE,310U;TX_BUFFER1_SIZE,55U;RTC_SYNCH_PREDIV,0x00F9;TX_BUFFER2_SIZE,310U
CONF3.Mcu.UserName=STM32U575ZITxQ
CONF3.MultiConf.NbConfig=3
CONF3.MxCube.Version=6.6.0
CONF3.MxDb.Version=DB.6.0.50
CONF3.NVIC.ForceEnableDMAVector=true
CONF3.NVIC.I2C3_ER_IRQn=true\:0\:0\:false\:false\:true\:true\:true\:true
CONF3.NVIC.I2C3_EV_IRQn=true\:0\:0\:false\:false\:true\:true\:true\:true
CONF3.NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
CONF3.PC0.GPIO_Pu=GPIO_PULLUP
CONF3.PC0.Mode=I2C
CONF3.PC0.Signal=I2C3_SCL
CONF3.PC1.GPIO_Pu=GPIO_PULLUP
CONF3.PC1.Mode=I2C
CONF3.PC1.Signal=I2C3_SDA
CONF3.PWR.DMA2DPowerDownInStopMode=PWR_DMA2DRAM_FULL_STOP_RETENTION
CONF3.PWR.Dcache1PowerDownInStopMode=PWR_DCACHE1_FULL_STOP_RETENTION
CONF3.PWR.PKA32RAMPowerDownInStopMode=PWR_PKA32RAM_FULL_STOP_RETENTION
CONF3.PWR.PeriphPowerDownInStopMode=PWR_PERIPHRAM_FULL_STOP_RETENTION
CONF3.PWR.RAM1Page1PowerDownInStopMode=PWR_SRAM1_PAGE1_STOP_RETENTION
CONF3.PWR.RAM1Page2PowerDownInStopMode=PWR_SRAM1_PAGE2_STOP_RETENTION
CONF3.PWR.RAM1Page3PowerDownInStopMode=PWR_SRAM1_PAGE3_STOP_RETENTION
CONF3.PWR.RAM2Page1PowerDownInStopMode=PWR_SRAM2_PAGE1_STOP_RETENTION
CONF3.PWR.RAM2Page2PowerDownInStopMode=PWR_SRAM2_PAGE2_STOP_RETENTION
CONF3.PWR.RAM3Page1PowerDownInStopMode=PWR_SRAM3_PAGE1_STOP_RETENTION
CONF3.PWR.RAM3Page2PowerDownInStopMode=PWR_SRAM3_PAGE2_STOP_RETENTION
CONF3.PWR.RAM3Page3PowerDownInStopMode=PWR_SRAM3_PAGE3_STOP_RETENTION
CONF3.PWR.RAM3Page4PowerDownInStopMode=PWR_SRAM3_PAGE4_STOP_RETENTION
CONF3.PWR.RAM3Page5PowerDownInStopMode=PWR_SRAM3_PAGE5_STOP_RETENTION
CONF3.PWR.RAM3Page6PowerDownInStopMode=PWR_SRAM3_PAGE6_STOP_RETENTION
CONF3.PWR.RAM3Page7PowerDownInStopMode=PWR_SRAM3_PAGE7_STOP_RETENTION
CONF3.PWR.RAM3Page8PowerDownInStopMode=PWR_SRAM3_PAGE8_STOP_RETENTION
CONF3.PinOutPanel.RotationAngle=0
CONF3.RCC.ADCFreq_Value=16000000
CONF3.RCC.ADF1Freq_Value=4000000
CONF3.RCC.AHBFreq_Value=160000000
CONF3.RCC.APB1Freq_Value=160000000
CONF3.RCC.APB1TimFreq_Value=160000000
CONF3.RCC.APB2Freq_Value=160000000
CONF3.RCC.APB2TimFreq_Value=160000000
CONF3.RCC.APB3Freq_Value=160000000
CONF3.RCC.CK48CLockSelection=RCC_CLK48CLKSOURCE_HSI48
CONF3.RCC.CK48Freq_Value=48000000
CONF3.RCC.CRSFreq_Value=48000000
CONF3.RCC.CortexFreq_Value=160000000
CONF3.RCC.DACCLockSelectionVirtual=RCC_DAC1CLKSOURCE_LSI
CONF3.RCC.DACCLockSelectionVirtualString=RCC_DAC1CLKSOURCE_LSI
CONF3.RCC.DACFreq_Value=32000
CONF3.RCC.EPOD_VALUE=4000000
CONF3.RCC.FCLKCortexFreq_Value=160000000
CONF3.RCC.FDCANFreq_Value=160000000
CONF3.RCC.FamilyName=M
CONF3.RCC.HCLKFreq_Value=160000000
CONF3.RCC.HSE_VALUE=16000000
CONF3.RCC.HSI48_VALUE=48000000
CONF3.RCC.HSI_VALUE=16000000
CONF3.RCC.I2C1Freq_Value=16000000
CONF3.RCC.I2C2Freq_Value=16000000
CONF3.RCC.I2C3CLockSelection=RCC_I2C3CLKSOURCE_MSIK
CONF3.RCC.I2C3Freq_Value=4000000
CONF3.RCC.I2C4Freq_Value=16000000
CONF3.RCC.LPTIM2CLockSelection=RCC_LPTIM2CLKSOURCE_PCLK1
CONF3.RCC.LPTIM2CLockSelectionVirtual=RCC_LPTIM2CLKSOURCE_PCLK1
CONF3.RCC.LPTIM2Freq_Value=160000000
CONF3.RCC.LPUART1CLockSelection=RCC_LPUART1CLKSOURCE_PCLK3
CONF3.RCC.LPUART1CLockSelectionVirtual=RCC_LPUART1CLKSOURCE_PCLK3
CONF3.RCC.LPUART1Freq_Value=160000000
CONF3.RCC.LSCOPinFreq_Value=32000
CONF3.RCC.LSE_VALUE=32768
CONF3.RCC.LSIDIV_VALUE=32000
CONF3.RCC.LSI_VALUE=32000
CONF3.RCC.MCO1PinFreq_Value=160000000
CONF3.RCC.MDF1Freq_Value=4000000
CONF3.RCC.MSI_VALUE=4000000
CONF3.RCC.OCTOSPIMFreq_Value=4000000
CONF3.RCC.PLL2PoutputFreq_Value=258000000
CONF3.RCC.PLL2QoutputFreq_Value=258000000
CONF3.RCC.PLL2RoutputFreq_Value=258000000
CONF3.RCC.PLL3PoutputFreq_Value=258000000
CONF3.RCC.PLL3QoutputFreq_Value=258000000
CONF3.RCC.PLL3RoutputFreq_Value=258000000
CONF3.RCC.PLLN=80
CONF3.RCC.PLLPoutputFreq_Value=160000000
CONF3.RCC.PLLQoutputFreq_Value=160000000
CONF3.RCC.PLLRCLKFreq_Value=160000000
CONF3.RCC.RNGFreq_Value=16000000
CONF3.RCC.SAI1Freq_Value=16000000
CONF3.RCC.SAI2Freq_Value=16000000
CONF3.RCC.SDMMCClockSelection=RCC_SDMMCCLKSOURCE_PLL1
CONF3.RCC.SDMMCFreq_Value=160000000
CONF3.RCC.SPI1Freq_Value=16000000
CONF3.RCC.SPI2Freq_Value=16000000
CONF3.RCC.SPI3Freq_Value=16000000
CONF3.RCC.SYSCLKFreq_VALUE=160000000
CONF3.RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
CONF3.RCC.UART4CLockSelection=RCC_UART4CLKSOURCE_PCLK1
CONF3.RCC.UART4CLockSelectionVirtual=RCC_UART4CLKSOURCE_PCLK1
CONF3.RCC.UART4Freq_Value=160000000
CONF3.RCC.UART5CLockSelection=RCC_UART5CLKSOURCE_PCLK1
CONF3.RCC.UART5CLockSelectionVirtual=RCC_UART5CLKSOURCE_PCLK1
CONF3.RCC.UART5Freq_Value=160000000
CONF3.RCC.USART1CLockSelection=RCC_USART1CLKSOURCE_PCLK2
CONF3.RCC.USART1CLockSelectionVirtual=RCC_USART1CLKSOURCE_PCLK2
CONF3.RCC.USART1Freq_Value=160000000
CONF3.RCC.USART2CLockSelection=RCC_USART2CLKSOURCE_PCLK1
CONF3.RCC.USART2CLockSelectionVirtual=RCC_USART2CLKSOURCE_PCLK1
CONF3.RCC.USART2Freq_Value=160000000
CONF3.RCC.USART3CLockSelection=RCC_USART3CLKSOURCE_PCLK1
CONF3.RCC.USART3CLockSelectionVirtual=RCC_USART3CLKSOURCE_PCLK1
CONF3.RCC.USART3Freq_Value=160000000
CONF3.RCC.USBFreq_Value=48000000
CONF3.RCC.VCOInput2Freq_Value=4000000
CONF3.RCC.VCOInput3Freq_Value=4000000
CONF3.RCC.VCOInputFreq_Value=4000000
CONF3.RCC.VCOOutputFreq_Value=320000000
CONF3.RCC.VCOPLL2OutputFreq_Value=516000000
CONF3.RCC.VCOPLL3OutputFreq_Value=516000000
CONF3.S1.Q1.F1.FuncUserName=Slave_Receive_Data_1
CONF3.S1.Q1.F1.FuncVirtualPinList=VP_LPBAMI2C3_VS_SLAVERECEIVE_DATA
CONF3.S1.Q1.F1.IpInstanceName=LPBAMI2C3
CONF3.S1.Q1.F1.LPBAMI2C3.BufferName=aRxBuffer1
CONF3.S1.Q1.F1.LPBAMI2C3.BufferOffset=0
CONF3.S1.Q1.F1.LPBAMI2C3.DevAddress_SRX_DATA=0
CONF3.S1.Q1.F1.LPBAMI2C3.NodeLevel_SLAVERECEIVE_DATA=LPBAM_I2C_SLAVERX_DATAQ_CONFIG_NODE
CONF3.S1.Q1.F1.LPBAMI2C3.QUEUE_NAME=Slave_Q
CONF3.S1.Q1.F1.LPBAMI2C3.SequenceNumber_SRX_DATA=2
CONF3.S1.Q1.F1.LPBAMI2C3.Size=55
CONF3.S1.Q1.F1.LPBAMI2C3.Size_SRX_DATA=55
CONF3.S1.Q1.F1.VP_LPBAMI2C3_VS_SLAVERECEIVE_DATA.Mode=SLAVERECEIVE_DATA
CONF3.S1.Q1.F1.VP_LPBAMI2C3_VS_SLAVERECEIVE_DATA.Signal=LPBAMI2C3_VS_SLAVERECEIVE_DATA
CONF3.S1.Q1.F2.FuncUserName=Slave_Transmit_Data_1
CONF3.S1.Q1.F2.FuncVirtualPinList=VP_LPBAMI2C3_VS_SLAVETRANSMIT_DATA
CONF3.S1.Q1.F2.IpInstanceName=LPBAMI2C3
CONF3.S1.Q1.F2.LPBAMI2C3.BufferName=aTxBuffer2
CONF3.S1.Q1.F2.LPBAMI2C3.BufferOffset=0
CONF3.S1.Q1.F2.LPBAMI2C3.DevAddress_STX_DATA=0
CONF3.S1.Q1.F2.LPBAMI2C3.NodeLevel_SLAVETRANSMIT_DATA=LPBAM_I2C_SLAVETX_DATAQ_CONFIG_NODE
CONF3.S1.Q1.F2.LPBAMI2C3.QUEUE_NAME=Slave_Q
CONF3.S1.Q1.F2.LPBAMI2C3.SequenceNumber_STX_DATA=2
CONF3.S1.Q1.F2.LPBAMI2C3.Size=310
CONF3.S1.Q1.F2.LPBAMI2C3.Size_STX_DATA=337
CONF3.S1.Q1.F2.VP_LPBAMI2C3_VS_SLAVETRANSMIT_DATA.Mode=SLAVETRANSMIT_DATA
CONF3.S1.Q1.F2.VP_LPBAMI2C3_VS_SLAVETRANSMIT_DATA.Signal=LPBAMI2C3_VS_SLAVETRANSMIT_DATA
CONF3.S1.Q1.FuncCount=2
CONF3.S1.Q1.FuncLastActive=F2
CONF3.S1.Q1.IpInstanceName=LPBAMQUEUE
CONF3.S1.Q1.LPBAMQUEUE.Interrupt1=DMA_IT_DTE
CONF3.S1.Q1.LPBAMQUEUE.Interrupt2=DMA_IT_ULE
CONF3.S1.Q1.LPBAMQUEUE.Interrupt3=DMA_IT_USE
CONF3.S1.Q1.LPBAMQUEUE.Interrupt6=DMA_IT_TO
CONF3.S1.Q1.QueueCircularity=0
CONF3.S1.Q1.QueueUserName=Slave
CONF3.S1.Q1.QueueVirtualPinList=VP_LPBAMQUEUE_VS_QUEUE
CONF3.S1.Q1.VP_LPBAMQUEUE_VS_QUEUE.Mode=QUEUEMODE
CONF3.S1.Q1.VP_LPBAMQUEUE_VS_QUEUE.Signal=LPBAMQUEUE_VS_QUEUE
CONF3.S1.QueueCount=1
CONF3.S1.QueueLastActive=Q1
CONF3.S1.ScenarioName=ReloadSeq
CONF3.ScenarioCount=1
CONF3.VP_I2C3_VS_I2C_LPBAM.Mode=LPBAMSPECIFIC
CONF3.VP_I2C3_VS_I2C_LPBAM.Signal=I2C3_VS_I2C_LPBAM
CONF3.VP_LPBAM_VS_SIG1.Mode=SmartRun
CONF3.VP_LPBAM_VS_SIG1.Signal=LPBAM_VS_SIG1
CONF3.VP_LPBAM_VS_SIG2.Signal=LPBAM_VS_SIG2
CONF3.VP_LPBAM_VS_SIG4.Mode=LPDMA1
CONF3.VP_LPBAM_VS_SIG4.Signal=LPBAM_VS_SIG4
CONF3.VP_LPBAM_VS_SIGPW.Signal=LPBAM_VS_SIGPW
CONF3.VP_LPBAM_VS_SIGPWOPT.Signal=LPBAM_VS_SIGPWOPT
CONF3.VP_PWR_VS_DBSignals.Mode=DisableDeadBatterySignals
CONF3.VP_PWR_VS_DBSignals.Signal=PWR_VS_DBSignals
CONF3.VP_PWR_VS_LPOM.Mode=PowerOptimisation
CONF3.VP_PWR_VS_LPOM.Signal=PWR_VS_LPOM
CONF3.VP_SYS_VS_Systick.Mode=SysTick
CONF3.VP_SYS_VS_Systick.Signal=SYS_VS_Systick
CONF3.board=custom
Mcu.Family=STM32U5
Mcu.Name=STM32U575ZITxQ
Mcu.Package=LQFP144
Mcu.UserConstants=RX_BUFFER1_SIZE,55U;RTC_ASYNCH_PREDIV,0x7F;LPBAM_I2C3_ADDRESS,0x35U;RX_BUFFER2_SIZE,310U;TX_BUFFER1_SIZE,55U;RTC_SYNCH_PREDIV,0x00F9;TX_BUFFER2_SIZE,310U
MultiConf.NbConfig=3
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=EWARM V8.50
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2021 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"

/* USER CODE BEGIN Includes */
#include "lpbam_master.h"
#include "lpbam_slave.h"
/* USER CODE END Includes */

DMA_HandleTypeDef handle_LPDMA1_Channel0;

I2C_HandleTypeDef hi2c3;
RTC_HandleTypeDef hrtc;
/* USER CODE BEGIN PV */
/* Push Button State */
__IO uint32_t PushButtonState = PB_NOT_PRESSED;

/* Transmission Buffers */
uint8_t aTxBuffer1[TX_BUFFER1_SIZE] =
" ############### LPBAM I2C Application ############### ";

uint8_t aTxBuffer2[TX_BUFFER2_SIZE] =
" ############### This application shows how to use LPBAM I2C advanced utility to perform sequential data transfer in master and slave mode ###############\
  ############### This application shows how to use LPBAM I2C advanced utility to perform sequential data transfer in master and slave mode ############### ";

/* Reception Buffers */
uint8_t aRxBuffer1[RX_BUFFER1_SIZE];
uint8_t aRxBuffer2[RX_BUFFER2_SIZE];
/* USER CODE END PV */

void SystemClock_Config(void);
static void SystemPower_Config(void);
static void MX_LPDMA1_Init(void);
static void MX_GPIO_Init(void);
static void MX_ICACHE_Init(void);
/* USER CODE BEGIN PFP */
static void Enter_Stop2_Mode(void);
static uint16_t Buffercmp(uint8_t* pBuffer1, uint8_t* pBuffer2, uint16_t BufferLength);
/* USER CODE END PFP */

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the System Power */
  SystemPower_Config();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  MX_LPDMA1_Init();
  MX_GPIO_Init();
  MX_ICACHE_Init();
  /* USER CODE BEGIN 2 */

  /* Initialize LED1, LED2 and LED3 : GREEN, BLUE and RED leds */
  BSP_LED_Init(LED1);
  BSP_LED_Init(LED2);
  BSP_LED_Init(LED3);

#ifdef MASTER_BOARD

  /* Initialize Push Button */
  BSP_PB_Init(BUTTON_USER, BUTTON_MODE_EXTI);

  /* LPBAM Master application init */
  MX_Master_Init();

  /* LPBAM Master application ReloadSeq scenario init */
  MX_Master_ReloadSeq_Init();

  /* LPBAM Master application ReloadSeq scenario build */
  MX_Master_ReloadSeq_Build();

  /* LPBAM Master application ReloadSeq scenario link */
  MX_Master_ReloadSeq_Link(&handle_LPDMA1_Channel0);

  /* Turn on LED2 */
  BSP_LED_On(LED2);

  /* Wait for next push button press to stop the LPBAM Master application ReloadSeq scenario */
  while (PushButtonState == PB_NOT_PRESSED);

  /* Reset push button state */
  PushButtonState = PB_NOT_PRESSED;

  /* Turn off LED2 */
  BSP_LED_Off(LED2);

  /* LPBAM Master application ReloadSeq scenario start */
  MX_Master_ReloadSeq_Start(&handle_LPDMA1_Channel0);

  /* Enter Stop2 mode */
  Enter_Stop2_Mode();

  /* LPBAM Master application ReloadSeq scenario stop */
  MX_Master_ReloadSeq_Stop(&handle_LPDMA1_Channel0);

  /* LPBAM Master application ReloadSeq scenario unlink */
  MX_Master_ReloadSeq_UnLink(&handle_LPDMA1_Channel0);

  /* LPBAM Master application ReloadSeq scenario de-init */
  MX_Master_ReloadSeq_DeInit();

  /* Compare aRxBuffer2 with expected content */
  if (Buffercmp(aTxBuffer2, aRxBuffer2, TX_BUFFER2_SIZE) != 0U)
  {
    Error_Handler();
  }

#else

  /* LPBAM Slave application init */
  MX_Slave_Init();

  /* LPBAM Slave application ReloadSeq scenario init */
  MX_Slave_ReloadSeq_Init();

  /* LPBAM Slave application ReloadSeq scenario build */
  MX_Slave_ReloadSeq_Build();

  /* LPBAM Slave application ReloadSeq scenario link */
  MX_Slave_ReloadSeq_Link(&handle_LPDMA1_Channel0);

  /* LPBAM Slave application ReloadSeq scenario start */
  MX_Slave_ReloadSeq_Start(&handle_LPDMA1_Channel0);

  /* Enter Stop2 mode */
  Enter_Stop2_Mode();

  /* LPBAM Slave application ReloadSeq scenario stop */
  MX_Slave_ReloadSeq_Stop(&handle_LPDMA1_Channel0);

  /* LPBAM Slave application ReloadSeq scenario unlink */
  MX_Slave_ReloadSeq_UnLink(&handle_LPDMA1_Channel0);

  /* LPBAM Slave application ReloadSeq scenario de-init */
  MX_Slave_ReloadSeq_DeInit();

  /* Compare aRxBuffer1 with expected content */
  if (Buffercmp(aTxBuffer1, aRxBuffer1, TX_BUFFER1_SIZE) != 0U)
  {
    Error_Handler();
  }

#endif /* MASTER_BOARD */

  /* Turn on LED1 */
  BSP_LED_On(LED1);

  /* USER CODE END 2 */

  /* Infinite loop */
  while (1)
  {

  }
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Configure the main internal regulator output voltage
  */
  if (HAL_PWREx_ControlVoltageScaling(PWR_REGULATOR_VOLTAGE_SCALE1) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_MSI;
  RCC_OscInitStruct.MSIState = RCC_MSI_ON;
  RCC_OscInitStruct.MSICalibrationValue = RCC_MSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.MSIClockRange = RCC_MSIRANGE_4;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_MSI;
  RCC_OscInitStruct.PLL.PLLMBOOST = RCC_PLLMBOOST_DIV1;
  RCC_OscInitStruct.PLL.PLLM = 1;
  RCC_OscInitStruct.PLL.PLLN = 80;
  RCC_OscInitStruct.PLL.PLLP = 2;
  RCC_OscInitStruct.PLL.PLLQ = 2;
  RCC_OscInitStruct.PLL.PLLR = 2;
  RCC_OscInitStruct.PLL.PLLRGE = RCC_PLLVCIRANGE_0;
  RCC_OscInitStruct.PLL.PLLFRACN = 0;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2
                              |RCC_CLOCKTYPE_PCLK3;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB3CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_4) != HAL_OK)
  {
    Error_Handler();
  }
}

/**
  * @brief Power Configuration
  * @retval None
  */
static void SystemPower_Config(void)
{
  HAL_PWREx_EnableVddIO2();

  /*
   * Disable the internal Pull-Up in Dead Battery pins of UCPD peripheral
   */
  HAL_PWREx_DisableUCPDDeadBattery();

  /*
   * Switch to SMPS regulator instead of LDO
   */
  if (HAL_PWREx_ConfigSupply(PWR_SMPS_SUPPLY) != HAL_OK)
  {
    Error_Handler();
  }
}

static void MX_ICACHE_Init(void)
{

  /** Enable instruction cache in 1-way (direct mapped cache)
  */
  if (HAL_ICACHE_ConfigAssociativityMode(ICACHE_1WAY) != HAL_OK)
  {
    Error_Handler();
  }
  if (HAL_ICACHE_Enable() != HAL_OK)
  {
    Error_Handler();
  }

}

static void MX_LPDMA1_Init(void)
{

  /* Peripheral clock enable */
  __HAL_RCC_LPDMA1_CLK_ENABLE();

  /* LPDMA1 interrupt Init */
    HAL_NVIC_SetPriority(LPDMA1_Channel0_IRQn, 0, 0);
    HAL_NVIC_EnableIRQ(LPDMA1_Channel0_IRQn);

  handle_LPDMA1_Channel0.Instance = LPDMA1_Channel0;
  handle_LPDMA1_Channel0.InitLinkedList.Priority = DMA_LOW_PRIORITY_LOW_WEIGHT;
  handle_LPDMA1_Channel0.InitLinkedList.LinkStepMode = DMA_LSM_FULL_EXECUTION;
  handle_LPDMA1_Channel0.InitLinkedList.TransferEventMode = DMA_TCEM_LAST_LL_ITEM_TRANSFER;
  handle_LPDMA1_Channel0.InitLinkedList.LinkedListMode = DMA_LINKEDLIST_NORMAL;
  if (HAL_DMAEx_List_Init(&handle_LPDMA1_Channel0) != HAL_OK)
  {
    Error_Handler();
  }
  if (HAL_DMA_ConfigChannelAttributes(&handle_LPDMA1_Channel0, DMA_CHANNEL_NPRIV) != HAL_OK)
  {
    Error_Handler();
  }

}

static void MX_GPIO_Init(void)
{
  GPIO_InitTypeDef GPIO_InitStruct = {0};

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOE_CLK_ENABLE();
  __HAL_RCC_GPIOC_CLK_ENABLE();
  __HAL_RCC_GPIOF_CLK_ENABLE();
  __HAL_RCC_GPIOH_CLK_ENABLE();
  __HAL_RCC_GPIOA_CLK_ENABLE();
  __HAL_RCC_GPIOB_CLK_ENABLE();
  __HAL_RCC_GPIOG_CLK_ENABLE();
  __HAL_RCC_GPIOD_CLK_ENABLE();

  /*Configure GPIO pins : PE2 PE3 PE4 PE5
                           PE6 PE7 PE8 PE9
                           PE10 PE11 PE12 PE13
                           PE14 PE15 PE0 PE1 */
  GPIO_InitStruct.Pin = GPIO_PIN_2|GPIO_PIN_3|GPIO_PIN_4|GPIO_PIN_5
                          |GPIO_PIN_6|GPIO_PIN_7|GPIO_PIN_8|GPIO_PIN_9
                          |GPIO_PIN_10|GPIO_PIN_11|GPIO_PIN_12|GPIO_PIN_13
                          |GPIO_PIN_14|GPIO_PIN_15|GPIO_PIN_0|GPIO_PIN_1;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOE, &GPIO_InitStruct);

  /*Configure GPIO pins : PC13 PC14 PC15 PC0
                           PC1 PC2 PC3 PC6
                           PC7 PC8 PC9 PC10
                           PC11 PC12 */
  GPIO_InitStruct.Pin = GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15|GPIO_PIN_0
                          |GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3|GPIO_PIN_6
                          |GPIO_PIN_7|GPIO_PIN_8|GPIO_PIN_9|GPIO_PIN_10
                          |GPIO_PIN_11|GPIO_PIN_12;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

  /*Configure GPIO pins : PF0 PF1 PF2 PF3
                           PF4 PF5 PF6 PF7
                           PF8 PF9 PF10 PF11
                           PF12 PF13 PF14 PF15 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_7
                          |GPIO_PIN_8|GPIO_PIN_9|GPIO_PIN_10|GPIO_PIN_11
                          |GPIO_PIN_12|GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOF, &GPIO_InitStruct);

  /*Configure GPIO pins : PH0 PH1 PH3 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_3;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOH, &GPIO_InitStruct);

  /*Configure GPIO pins : PA0 PA1 PA2 PA3
                           PA4 PA5 PA6 PA7
                           PA8 PA9 PA10 PA11
                           PA12 PA13 PA14 PA15 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_7
                          |GPIO_PIN_8|GPIO_PIN_9|GPIO_PIN_10|GPIO_PIN_11
                          |GPIO_PIN_12|GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pins : PB0 PB1 PB2 PB10
                           PB11 PB13 PB14 PB15
                           PB3 PB4 PB5 PB6
                           PB7 PB8 PB9 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_10
                          |GPIO_PIN_11|GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15
                          |GPIO_PIN_3|GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6
                          |GPIO_PIN_7|GPIO_PIN_8|GPIO_PIN_9;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

  /*Configure GPIO pins : PG0 PG1 PG2 PG3
                           PG4 PG5 PG6 PG7
                           PG8 PG9 PG10 PG12
                           PG13 PG14 PG15 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_7
                          |GPIO_PIN_8|GPIO_PIN_9|GPIO_PIN_10|GPIO_PIN_12
                          |GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOG, &GPIO_InitStruct);

  /*Configure GPIO pins : PD8 PD9 PD10 PD11
                           PD12 PD13 PD14 PD15
                           PD0 PD1 PD2 PD3
                           PD4 PD5 PD6 PD7 */
  GPIO_InitStruct.Pin = GPIO_PIN_8|GPIO_PIN_9|GPIO_PIN_10|GPIO_PIN_11
                          |GPIO_PIN_12|GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15
                          |GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_7;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOD, &GPIO_InitStruct);

}

/* USER CODE BEGIN 4 */
/**
  * @brief Enter Stop2 mode and checks whether the system was in Stop2 or not.
  * @param None
  * @retval None
  */
static void Enter_Stop2_Mode(void)
{
  /* Enter the system to STOP2 mode */
  __HAL_RCC_PWR_CLK_ENABLE();
  HAL_PWREx_EnterSTOP2Mode(PWR_STOPENTRY_WFI);

  /* Check that the system was resumed from stop 2 */
  if (__HAL_PWR_GET_FLAG(PWR_FLAG_STOPF) == 0U)
  {
    Error_Handler();
  }

  /* Clear stop flag */
  __HAL_PWR_CLEAR_FLAG(PWR_FLAG_STOPF);

  /* Check that stop flag is cleared */
  if (__HAL_PWR_GET_FLAG(PWR_FLAG_STOPF) != 0U)
  {
    Error_Handler();
  }
}

/**
  * @brief  BSP push button callback
  * @par    None
  * @retval None
  */
void BSP_PB_Callback(Button_TypeDef Button)
{
  PushButtonState = PB_PRESSED;
}

/**
  * @brief  Compares two buffers.
  * @param  pBuffer1, pBuffer2: buffers to be compared.
  * @param  BufferLength: buffer's length
  * @retval 0   : pBuffer1 identical to pBuffer2
  *         > 0 : pBuffer1 differs from pBuffer2
  */
static uint16_t Buffercmp(uint8_t* pBuffer1, uint8_t* pBuffer2, uint16_t BufferLength)
{
  while (BufferLength--)
  {
    if ((*pBuffer1) != *pBuffer2)
    {
      return BufferLength;
    }

    pBuffer1++;
    pBuffer2++;
  }

  return 0;
}
/* USER CODE END 4 */

void Error_Handler(void)
{
  /* USER CODE BEGIN Error_Handler_Debug */
  /* User can add his own implementation to report the HAL error return state */
  __disable_irq();

  /* Turn LED3 on */
  BSP_LED_On(LED3);

  while (1)
  {
  }
  /* USER CODE END Error_Handler_Debug */
}
