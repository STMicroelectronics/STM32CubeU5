<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LPTIM_IC_LSE.ewp</path>
  </project>
  <batchBuild />
</workspace>
