# Keil uVision project I2C_TwoBoards_RestartAdvComIT.uvprojx, settings and files
target I2C_TwoBoards_RestartAdvComIT (6140001::V6.14.1::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: I2C_TwoBoards_RestartAdvComIT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,__DBG_ITM
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U5xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
    ./: Retarget.c Serial.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_exti.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
software components: CMSIS:CORE 4.3.0
