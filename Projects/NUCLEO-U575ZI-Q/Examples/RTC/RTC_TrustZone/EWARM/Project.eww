<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTC_TrustZone_S.ewp</path>
  </project><project>
    <path>$WS_DIR$\RTC_TrustZone_NS.ewp</path>
  </project>
  <batchBuild />
</workspace>
