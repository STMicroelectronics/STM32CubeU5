<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HASH_HMAC_SHA1MD5.ewp</path>
  </project>
  <batchBuild />
</workspace>
