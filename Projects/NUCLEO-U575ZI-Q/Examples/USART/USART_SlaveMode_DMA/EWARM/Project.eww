<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USART_SlaveMode_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
