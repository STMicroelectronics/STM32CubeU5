# Keil uVision project GTZC_TZSC_MPCBB_TrustZone_NS.uvprojx, settings and files
target GTZC_TZSC_MPCBB_TrustZone_NS (6140001::V6.14.1::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x00200000) IROM2(0x0C000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: GTZC_TZSC_MPCBB_TrustZone_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../NonSecure/Inc;  ../Secure_nsclib;  ../../../../../../Drivers/BSP/STM32U5xx_Nucleo;  ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;  ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;  ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;  ../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  link misc: ../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/NonSecure
    ../NonSecure/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32u5xx_ns.c
software components: CMSIS:CORE 4.3.0
