# IAR project UART_WakeUpFromStopUsingFIFO.ewp, settings and files
configuration UART_WakeUpFromStopUsingFIFO (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/lpbam; ../../../../../../Utilities/lpbam/STM32U5; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART_WakeUpFromStopUsingFIFO.hex
  ILINK.IlinkOutputFile: UART_WakeUpFromStopUsingFIFO.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: main.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
