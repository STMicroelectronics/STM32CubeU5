# Keil uVision project SMBUS_TwoBoards_ComIT_Slave.uvprojx, settings and files
target SMBUS_TwoBoards_ComIT_Slave (ARM-ADS)
  device: STM32U575ZITxQ STMicroelectronics
  cpu: IRAM(0x30000000-0x3003FFFF) IROM(0x0C000000-0xC0FDFFF) IROM2(0x0C0FE000-0xC0FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: SMBUS_TwoBoards_ComIT_Slave +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U5xx_Nucleo
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_exti.c stm32u5xx_hal_smbus_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_smbus.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
software components: CMSIS:CORE 4.3.0
