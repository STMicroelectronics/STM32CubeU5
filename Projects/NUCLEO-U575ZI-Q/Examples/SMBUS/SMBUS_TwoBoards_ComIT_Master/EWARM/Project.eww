<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SMBUS_TwoBoards_ComIT_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>
