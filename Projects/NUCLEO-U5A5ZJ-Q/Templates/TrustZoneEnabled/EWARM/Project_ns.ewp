# IAR project Project_ns.ewp, settings and files
configuration NUCLEO-U5A5ZJ_Templates_TrustZoneEnable (ARM, debug)
  General.OGChipSelectEditMenu: STM32U5A5ZJ ST STM32U5A5ZJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U5A5xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\NonSecure\Inc; ..\Secure_nsclib; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32U5xx_Nucleo; ..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_ns.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32u5a5xx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ..\Secure_nsclib\secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32u5xx_ns.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_cordic.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dsi.c stm32u5xx_hal_exti.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_fmac.c stm32u5xx_hal_gfxmmu.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gpu2d.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_hcd.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_irda.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_lptim.c stm32u5xx_hal_ltdc.c stm32u5xx_hal_ltdc_ex.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_nand.c stm32u5xx_hal_nor.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_otfdec.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_pssi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_sdio.c stm32u5xx_hal_smartcard.c stm32u5xx_hal_smartcard_ex.c stm32u5xx_hal_smbus.c stm32u5xx_hal_smbus_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_wwdg.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_fmc.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32u5a5xx.s
  group Example/User
    ../NonSecure/Src/: main.c stm32u5xx_hal_msp.c stm32u5xx_it.c
