<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Tx_Module_Manager.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Tx_Module.ewp</path>
  </project>
  <batchBuild />
</workspace>
