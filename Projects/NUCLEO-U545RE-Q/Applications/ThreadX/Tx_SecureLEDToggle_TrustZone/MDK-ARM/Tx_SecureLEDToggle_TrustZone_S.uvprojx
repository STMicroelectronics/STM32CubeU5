# Keil uVision project Tx_SecureLEDToggle_TrustZone_S.uvprojx, settings and files
target Tx_SecureLEDToggle_TrustZone_S (6180000::V6.18::ARMCLANG)
  device: STM32U545RETx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.3
  cpu: IRAM(0x30000000-0x3002FFFF) IROM(0x0C000000-0xC03DFFF) IROM2(0x0C03E000-0xC03FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Tx_SecureLEDToggle_TrustZone_S +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U545xx
  c include: ../Secure/Inc;../Secure_nsclib;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/threadx/common/inc;../../../../../../Middlewares/ST/threadx/ports/cortex_m33/ac6/inc;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0xc000000 size 0x3e000
  memory RVCT5: ROM 0xc03e000 size 0x2000
  memory RVCT9: RAM 0x30000000 size 0x30000
  link misc: --import_cmse_lib_out=../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32u545xx.s
  group Application/User/Secure
    ../Secure/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c secure_nsc.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32u5xx_s.c
  group Middlewares/ThreadX/Core
    ../../../../../../Middlewares/ST/threadx/ports/cortex_m33/ac6/src/: tx_thread_secure_stack.c
software components: CMSIS:CORE 4.3.0
