# IAR project PWR_ModesSelection.ewp, settings and files
configuration PWR_ModesSelection (ARM, debug)
  General.OGChipSelectEditMenu: STM32U545RE ST STM32U545RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U545xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWR_ModesSelection.hex
  ILINK.IlinkOutputFile: PWR_ModesSelection.out
  ILINK.IlinkIcfFile: stm32u545xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u545xx.s
  group Application/User
    ../Src/: console.c lowpower_scenarios.c system_config.c main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_exti.c stm32u5xx_hal_cortex.c stm32u5xx_hal_icache.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
