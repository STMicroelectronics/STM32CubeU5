# IAR project Project.ewp, settings and files
configuration NUCLEO-U545RE-Q_Templates_LL_TrustZoneDisable (ARM, debug)
  General.OGChipSelectEditMenu: STM32U545RE ST STM32U545RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U545xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32u545xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_ll_adc.c stm32u5xx_ll_comp.c stm32u5xx_ll_cordic.c stm32u5xx_ll_crc.c stm32u5xx_ll_crs.c stm32u5xx_ll_dac.c stm32u5xx_ll_dma.c stm32u5xx_ll_exti.c stm32u5xx_ll_fmac.c stm32u5xx_ll_gpio.c stm32u5xx_ll_i2c.c stm32u5xx_ll_icache.c stm32u5xx_ll_lpgpio.c stm32u5xx_ll_lptim.c stm32u5xx_ll_lpuart.c stm32u5xx_ll_opamp.c stm32u5xx_ll_pwr.c stm32u5xx_ll_rcc.c stm32u5xx_ll_rng.c stm32u5xx_ll_rtc.c stm32u5xx_ll_spi.c stm32u5xx_ll_tim.c stm32u5xx_ll_usart.c stm32u5xx_ll_utils.c
  group Example/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Source/Templates/iar/: startup_stm32u545xx.s
  group Example/User
    ../Src/: main.c stm32u5xx_it.c
