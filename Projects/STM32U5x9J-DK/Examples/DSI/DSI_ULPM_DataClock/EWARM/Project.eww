<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DSI_ULPM_DataClock.ewp</path>
  </project>
  <batchBuild />
</workspace>
