# Keil uVision project Project.uvprojx, settings and files
target OSPI_NOR_MemoryMapped (6180000::V6.18::ARMCLANG)
  device: STM32U5A9NJHxQ STMicroelectronics
  pack: Keil.STM32U59x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0C0000) IRAM2(0x30000000,0x0C0000) IROM(0x08000000,0x00400000) IROM2(0x0C000000,0x00400000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U5A9xx
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U5x9J-DK
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x270000
  link misc: --diag_suppress=L6329
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U599J-DK
    ../../../../../../Drivers/BSP/STM32U5x9J-DK/: stm32u5x9j_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_usart.c
  group Example/MDK-ARM
    ./: startup_stm32u5a9xx.s
  group Example/User
    ../Src/: main.c stm32u5xx_hal_msp.c stm32u5xx_it.c
