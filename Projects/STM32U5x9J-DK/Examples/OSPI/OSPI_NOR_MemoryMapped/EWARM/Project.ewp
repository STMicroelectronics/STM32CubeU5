# IAR project Project.ewp, settings and files
configuration OSPI_NOR_MemoryMapped (ARM, debug)
  General.OGChipSelectEditMenu: STM32U5A9NJ ST STM32U5A9NJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U5A9xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U5x9J-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OSPI_NOR_MemoryMapped.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u5a9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U599J-DK
    ../../../../../../Drivers/BSP/STM32U5x9J-DK/: stm32u5x9j_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_usart.c
  group Example/EWARM
    ./: startup_stm32u5a9xx.s
  group Example/User
    ../Src/: main.c stm32u5xx_hal_msp.c stm32u5xx_it.c
