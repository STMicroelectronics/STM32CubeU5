# Keil uVision project Project.uvprojx, settings and files
target BSP (6180000::V6.18::ARMCLANG)
  device: STM32U5A9NJHxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0C0000) IRAM2(0x30000000,0x0C0000) IROM(0x08000000,0x00400000) IROM2(0x0C000000,0x00400000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U5A9xx,USE_FULL_ASSERT,USE_HAL_DRIVER,__TERMINAL_IO__,CUT_2_0,__DBG_ITM
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32U5x9J-DK;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/vl53l5cx/modules;../../../../../Drivers/BSP/Components/vl53l5cx/porting;..\..\..\..\..\Utilities\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT5: ROM 0xc000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x270000
  memory RVCT10: RAM 0x30000000 size 0xc0000
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/aps512xx/: aps512xx.c
    ../../../../../Drivers/BSP/Components/mx25um51245g/: mx25um51245g.c
    ../../../../../Drivers/BSP/Components/sitronix/: sitronix.c sitronix_reg.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
  group Drivers/BSP/Components/vl53l5cx
    ../../../../../Drivers/BSP/Components/vl53l5cx/porting/: platform.c
    ../../../../../Drivers/BSP/Components/vl53l5cx/: vl53l5cx.c
    ../../../../../Drivers/BSP/Components/vl53l5cx/modules/: vl53l5cx_api.c vl53l5cx_plugin_detection_thresholds.c vl53l5cx_plugin_motion_indicator.c vl53l5cx_plugin_xtalk.c
  group Drivers/BSP/STM32U5x9J_DK
    ../../../../../Drivers/BSP/STM32U5x9J-DK/: stm32u5x9j_discovery.c stm32u5x9j_discovery_bus.c stm32u5x9j_discovery_hspi.c stm32u5x9j_discovery_lcd.c stm32u5x9j_discovery_mmc.c stm32u5x9j_discovery_ospi.c stm32u5x9j_discovery_ranging_sensor.c stm32u5x9j_discovery_ts.c stm32u5x9j_discovery_env_sensors.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_cordic.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dsi.c stm32u5xx_hal_exti.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_fmac.c stm32u5xx_hal_gfxmmu.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gpu2d.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_hcd.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_irda.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_lptim.c stm32u5xx_hal_ltdc.c stm32u5xx_hal_ltdc_ex.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_nand.c stm32u5xx_hal_nor.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_otfdec.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_pssi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_smartcard.c stm32u5xx_hal_smartcard_ex.c stm32u5xx_hal_smbus.c stm32u5xx_hal_smbus_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_wwdg.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_fmc.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32u5a9xx.s
  group Example/User
    ../Src/: emmc.c hspi.c lcd.c led.c main.c ospi_nor.c ranging_sensor.c stm32u5xx_it.c touchscreen.c env_sensor.c
    ./: Serial.c Retarget.c
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
