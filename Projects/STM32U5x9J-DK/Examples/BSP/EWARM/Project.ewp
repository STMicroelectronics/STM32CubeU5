# IAR project Project.ewp, settings and files
configuration BSP (ARM, debug)
  General.OGChipSelectEditMenu: STM32U5A9NJ ST STM32U5A9NJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U5A9xx; USE_FULL_ASSERT; USE_HAL_DRIVER; __TERMINAL_IO__
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32U5x9J-DK; ..\..\..\..\..\Utilities\lcd; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\vl53l5cx\modules; ..\..\..\..\..\Drivers\BSP\Components\vl53l5cx\porting
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u5a9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/aps512xx/: aps512xx.c
    ../../../../../Drivers/BSP/Components/mx25um51245g/: mx25um51245g.c
    ../../../../../Drivers/BSP/Components/sitronix/: sitronix.c sitronix_reg.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/Components/VL53LL5CX
    ../../../../../Drivers/BSP/Components/vl53l5cx/porting/: platform.c
    ../../../../../Drivers/BSP/Components/vl53l5cx/: vl53l5cx.c
    ../../../../../Drivers/BSP/Components/vl53l5cx/modules/: vl53l5cx_api.c vl53l5cx_plugin_detection_thresholds.c vl53l5cx_plugin_motion_indicator.c vl53l5cx_plugin_xtalk.c
  group Drivers/BSP/STM32U5x9J_DK
    ../../../../../Drivers/BSP/STM32U5x9J-DK/: stm32u5x9j_discovery.c stm32u5x9j_discovery_bus.c stm32u5x9j_discovery_env_sensors.c stm32u5x9j_discovery_hspi.c stm32u5x9j_discovery_lcd.c stm32u5x9j_discovery_mmc.c stm32u5x9j_discovery_ospi.c stm32u5x9j_discovery_ranging_sensor.c stm32u5x9j_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dsi.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gfxmmu.c stm32u5xx_hal_gpio.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_ltdc.c stm32u5xx_hal_ltdc_ex.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pssi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32u5a9xx.s
  group Example/User
    ../Src/: emmc.c env_sensor.c hspi.c lcd.c led.c main.c ospi_nor.c ranging_sensor.c stm32u5xx_it.c touchscreen.c
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
