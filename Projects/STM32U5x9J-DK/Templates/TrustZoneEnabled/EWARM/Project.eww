<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Project_ns.ewp</path>
    </project>
    <batchBuild />
</workspace>
