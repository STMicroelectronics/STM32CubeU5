<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\OSPI_NOR_AutoPolling_DTR.ewp</path>
  </project>
  <batchBuild />
</workspace>
