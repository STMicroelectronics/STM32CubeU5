# IAR project ADF_AudioSoundDetector.ewp, settings and files
configuration ADF_AudioSoundDetector (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/B-U585I-IOT02A
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADF_AudioSoundDetector.hex
  ILINK.IlinkOutputFile: ADF_AudioSoundDetector.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c linked_list.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/B-U585I-IOT02A
    ../../../../../../Drivers/BSP/B-U585I-IOT02A/: b_u585i_iot02a_bus.c b_u585i_iot02a.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_mdf.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_exti.c stm32u5xx_hal_icache.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
