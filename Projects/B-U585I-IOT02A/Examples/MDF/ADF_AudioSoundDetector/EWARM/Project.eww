<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADF_AudioSoundDetector.ewp</path>
  </project>
  <batchBuild />
</workspace>
