# Keil uVision project ADF_AudioSoundDetector.uvprojx, settings and files
target ADF_AudioSoundDetector (6140001::V6.14.1::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: ADF_AudioSoundDetector +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/B-U585I-IOT02A
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c linked_list.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/B-U585I-IOT02A
    ../../../../../../Drivers/BSP/B-U585I-IOT02A/: b_u585i_iot02a_bus.c b_u585i_iot02a.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_mdf.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_exti.c stm32u5xx_hal_icache.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
software components: CMSIS:CORE 4.3.0
