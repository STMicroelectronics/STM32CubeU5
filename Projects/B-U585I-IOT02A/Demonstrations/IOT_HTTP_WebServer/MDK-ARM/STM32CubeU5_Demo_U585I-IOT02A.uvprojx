# Keil uVision project STM32CubeU5_Demo_U585I-IOT02A.uvprojx, settings and files
target STM32CubeU5_Demo_U585I-IOT02A (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.3
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: STM32CubeU5_Demo_U585I-IOT02A +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c include: ../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/B-U585I-IOT02A;../../../../../Drivers/BSP/Components/mx_wifi;../../../../../Middlewares/ST/STM32_Network_Library/Includes;../Core/Inc;../WebServer/App;../WebServer/App/wifi;../WebServer/App/web_addons;../WebServer/App/sensors;../WebServer/App/http;../WebServer/Target
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Demonstration/MDK-ARM
    ./: startup_stm32u585xx.s
  group Demonstration/User/Core
    ../Core/Src/: bsp.c console.c main.c stm32u5xx_hal_msp.c stm32u5xx_it.c system_config.c
  group Demonstration/User/WebServer/App
    ../WebServer/App/: webserver_main.c webserver_status.c
  group Demonstration/User/WebServer/App/http
    ../WebServer/App/http/: webserver_http_cmd.c webserver_http_encoder.c webserver_http_response.c
  group Demonstration/User/WebServer/App/sensors
    ../WebServer/App/sensors/: webserver_sensors.c
  group Demonstration/User/WebServer/App/web
    ../WebServer/App/web_addons/: css_main_res.c css_shunk_res.c favicon_res.c font_res.c html_res.c image_res.c js_main_res.c js_shunk_res.c json_res.c
  group Demonstration/User/WebServer/App/wifi
    ../WebServer/App/wifi/: webserver_wifi.c
  group Demonstration/User/WebServer/Target
    ../WebServer/Target/: net_interface.c
  group Doc
    ../: README.md
  group Drivers/BSP/B-U585I-IOT02A
    ../../../../../Drivers/BSP/B-U585I-IOT02A/: b_u585i_iot02a.c b_u585i_iot02a_bus.c b_u585i_iot02a_env_sensors.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
  group Drivers/BSP/Components/mx_wifi
    ../../../../../Drivers/BSP/Components/mx_wifi/: mx_wifi.c
    ../../../../../Drivers/BSP/Components/mx_wifi/io_pattern/: mx_wifi_spi.c
  group Drivers/BSP/Components/mx_wifi/core
    ../../../../../Drivers/BSP/Components/mx_wifi/core/: mx_rtos_abs.c mx_wifi_hci.c mx_wifi_ipc.c mx_address.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_gpio.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_lptim.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middleware/STM32_Network_Library/core
    ../../../../../Middlewares/ST/STM32_Network_Library/core/: net_address.c net_class_extension.c net_core.c net_os.c net_socket.c net_state.c
  group Middleware/STM32_Network_Library/netif
    ../../../../../Middlewares/ST/STM32_Network_Library/netif/wifi_if/mx_wifi/: net_mx_wifi.c
  group Middleware/STM32_Network_Library/services
    ../../../../../Middlewares/ST/STM32_Network_Library/services/: net_mbedtls.c
software components: CMSIS:CORE 4.3.0
