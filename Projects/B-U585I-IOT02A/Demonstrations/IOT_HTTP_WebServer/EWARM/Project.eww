<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32CubeU5_Demo_U585I-IOT02A.ewp</path>
  </project>
  <batchBuild />
</workspace>
