# IAR project WiFiBasics.ewp, settings and files
configuration WiFiBasics (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_DHCP; USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/STM32_Network_Library/Includes; ../../../../../../Drivers/BSP/Components/mx_wifi; ../../../../../../Drivers/BSP/Components/mx_wifi/core
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WiFiBasics.bin
  ILINK.IlinkOutputFile: WiFiBasics.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: console.c http_download.c main.c main_app.c net_interface.c ping.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c stm32u5xx_it.c test_echo_server.c
    ../../../../../../Drivers/BSP/Components/mx_wifi/io_pattern/: mx_wifi_spi.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components/mx_wifi
    ../../../../../../Drivers/BSP/Components/mx_wifi/core/: checksumutils.c mx_rtos_abs.c mx_wifi_hci.c mx_wifi_ipc.c mx_wifi_slip.c
    ../../../../../../Drivers/BSP/Components/mx_wifi/: mx_wifi.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/ST/STM32_Network_Library/core
    ../../../../../../Middlewares/ST/STM32_Network_Library/core/: net_address.c net_class_extension.c net_core.c net_os.c net_socket.c net_state.c
  group Middlewares/ST/STM32_Network_Library/netif
    ../../../../../../Middlewares/ST/STM32_Network_Library/netif/wifi_if/mx_wifi/: net_mx_wifi.c
  group Middlewares/ST/STM32_Network_Library/services
    ../../../../../../Middlewares/ST/STM32_Network_Library/services/: net_mbedtls.c
