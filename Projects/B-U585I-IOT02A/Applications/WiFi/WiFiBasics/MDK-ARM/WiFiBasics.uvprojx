# Keil uVision project WiFiBasics.uvprojx, settings and files
target WiFiBasics (6140001::V6.14.1::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x00200000) IROM2(0x0C000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: WiFiBasics +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_DHCP,USE_HAL_DRIVER,STM32U585xx
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_Network_Library/Includes;../../../../../../Drivers/BSP/Components/mx_wifi;../../../../../../Drivers/BSP/Components/mx_wifi/core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c console.c net_interface.c ping.c test_echo_server.c http_download.c main_app.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
    ../../../../../../Drivers/BSP/Components/mx_wifi/io_pattern/: mx_wifi_spi.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components/mx_wifi
    ../../../../../../Drivers/BSP/Components/mx_wifi/: mx_wifi.c
    ../../../../../../Drivers/BSP/Components/mx_wifi/core/: checksumutils.c mx_wifi_hci.c mx_wifi_ipc.c mx_wifi_slip.c mx_rtos_abs.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Middlewares/ST/STM32_Network_Library/core
    ../../../../../../Middlewares/ST/STM32_Network_Library/core/: net_address.c net_core.c net_os.c net_socket.c net_state.c net_class_extension.c
  group Middlewares/ST/STM32_Network_Library/netif
    ../../../../../../Middlewares/ST/STM32_Network_Library/netif/wifi_if/mx_wifi/: net_mx_wifi.c
  group Middlewares/ST/STM32_Network_Library/services
    ../../../../../../Middlewares/ST/STM32_Network_Library/services/: net_mbedtls.c
software components: CMSIS:CORE 4.3.0
