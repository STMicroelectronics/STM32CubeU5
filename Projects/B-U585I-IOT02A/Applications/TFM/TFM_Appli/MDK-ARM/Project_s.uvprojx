# Keil uVision project Project_s.uvprojx, settings and files
target B-U585I-IOT02A_TFM_Appli_S (6130001::V6.13.1::.\ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.4
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  AfterMake: postbuild.bat . "1.0.0" "secure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U585xx,USE_HAL_DRIVER,NDEBUG,BL2,SST_ENCRYPTION,TFM_PARTITION_PLATFORM,TFM_PSA_API=1,TFM_LVL=2,TFM_LEGACY_API,MULADDC_CANNOT_USE_R7,MBEDTLS_CONFIG_FILE=<tfm_mbedcrypto_config.h>,ITS_CREATE_FLASH_LAYOUT,SST_CREATE_FLASH_LAYOUT,FLOW_CONTROL
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../Linker;../Secure/Inc;../../../../../../Middlewares/Third_Party;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls;../../../../../../Middlewares/Third_Party/mbed-crypto/include/psa;../../../../../../Middlewares/Third_Party/trustedfirmware;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/spm;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/arch/include;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/include;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/ipc;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/ipc/include;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/platform;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/crypto;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/audit_logging;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/initial_attestation;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/initial_attestation/psa_manifest;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/app_rot;../../../../../../Middlewares/Third_Party/trustedfirmware/interface/include;../../../../../../Middlewares/Third_Party/trustedfirmware/interface/include/psa_manifest;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/include;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/driver;../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/inc;../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/util;../../../../../../Middlewares/Third_Party/trustedfirmware/lib/t_cose/inc;../../../../../../Middlewares/Third_Party/trustedfirmware/lib/t_cose/src;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/include;../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/attestation
  scatter file: .\tfm_common_s.sct
  link misc: --predefine=-I../../Linker
--predefine=-DBL2
--predefine=-DTFM_PSA_API
--diag_suppress L6314W --diag_suppress L6329W --diag_suppress L6312W
 --import-cmse-lib-out=veneer.o
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_pka.c
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32u5xx.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_slot_management.c psa_crypto_storage.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group Middlewares/trustedfirmware/core
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/initial_attestation/: attest_token.c attestation_core.c attestation_key.c tfm_attestation.c tfm_attestation_req_mngr.c tfm_attestation_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_generator.c crypto_hash.c crypto_init.c crypto_key.c crypto_mac.c tfm_crypto_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: ieee754.c qcbor_decode.c qcbor_encode.c UsefulBuf.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/internal_trusted_storage/flash/: its_flash.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs_dblock.c its_flash_fs_mblock.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/internal_trusted_storage/: its_utils.c tfm_internal_trusted_storage.c tfm_its_req_mngr.c tfm_its_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/ipc/: psa_client.c psa_service.c tfm_message_queue.c tfm_pools.c tfm_svcalls.c tfm_thread.c tfm_wait.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/util/: qcbor_util.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/spm/: spm_api.c spm_api_ipc.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/crypto/: sst_crypto_interface.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/: sst_encrypted_object.c sst_object_system.c sst_object_table.c sst_utils.c tfm_protected_storage.c tfm_sst_req_mngr.c tfm_sst_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/flash/: sst_flash.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/flash_fs/: sst_flash_fs.c sst_flash_fs_dblock.c sst_flash_fs_mblock.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/nv_counters/: sst_nv_counters.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/t_cose/src/: t_cose_psa_crypto_hash.c t_cose_psa_crypto_sign.c t_cose_sign1_sign.c t_cose_util.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/arch/: tfm_arch_v8m_main.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/: tfm_boot_data.c tfm_core.c tfm_core_log.c tfm_core_mem_check.c tfm_core_svcalls_ipc.c tfm_core_utils.c tfm_nspm_ipc.c tfm_secure_api.c tfm_spm_services.c tfm_utils.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/ns_callable/: tfm_psa_api_veneers.c tfm_veneers.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/platform/: platform_sp.c tfm_platform_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/app_rot/: tfm_app_rot.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common/: uart_stdout.c
  group Application/User
    ../Secure/Src/: low_level_com.c low_level_flash.c low_level_rng.c tick.c attest_hal.c dummy_boot_seed.c dummy_crypto_keys.c dummy_device_id.c dummy_nv_counters.c low_level_device.c spm_hal.c target_cfg.c tfm_platform_system.c mpu_armv8m_drv.c app_rot_test.c aes_alt.c ccm_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c gcm_alt.c rsa_alt.c md5_alt.c sha1_alt.c sha256_alt.c startup_stm32u5xx.c
software components: CMSIS:CORE 5.3.0
