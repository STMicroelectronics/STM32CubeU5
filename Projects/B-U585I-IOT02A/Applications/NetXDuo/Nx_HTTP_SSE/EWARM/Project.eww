<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nx_HTTP_SSE.ewp</path>
  </project>
  <batchBuild />
</workspace>
