<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Secure\Project_s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\NonSecure\Project_ns.ewp</path>
  </project>
  <batchBuild/>
</workspace>
