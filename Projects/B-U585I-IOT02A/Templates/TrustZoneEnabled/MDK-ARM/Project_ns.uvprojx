# Keil uVision project Project_ns.uvprojx, settings and files
target B-U585I-IOT02A_Templates_TrustZoneEnabled (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.5
  cpu: IROM(0x08100000-0x81FFFFF) IRAM(0x20040000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: $PROJ_FNAME$ +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U585xx,USE_HAL_DRIVER,USE_B_U585I_IOT02A
  c include: ../NonSecure/Inc;../Secure_nsclib;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/B-U585I-IOT02A;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/BSP/Components/vl53l5cx/porting;../../../../../Drivers/BSP/Components/vl53l5cx/modules
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x20040000 size 0x80000
  link misc: ../Secure_nsclib/secure_nsclib.o
  group Doc
    ../: README.md
  group Drivers/BSP/B-U585I-IOT02A
    ../../../../../Drivers/BSP/B-U585I-IOT02A/: b_u585i_iot02a.c b_u585i_iot02a_bus.c b_u585i_iot02a_camera.c b_u585i_iot02a_eeprom.c b_u585i_iot02a_env_sensors.c b_u585i_iot02a_light_sensor.c b_u585i_iot02a_motion_sensors.c b_u585i_iot02a_ospi.c b_u585i_iot02a_usbpd_pwr.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/aps6408/: aps6408.c
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/m24256/: m24256.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../Drivers/BSP/Components/stm32wb_at/: stm32wb_at.c stm32wb_at_ble.c stm32wb_at_client.c stm32wb_at_ll.c
    ../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
    ../../../../../Drivers/BSP/Components/veml6030/: veml6030.c veml6030_reg.c
  group Drivers/BSP/Components/VL53L5CX
    ../../../../../Drivers/BSP/Components/vl53l5cx/porting/: platform.c
    ../../../../../Drivers/BSP/Components/vl53l5cx/: vl53l5cx.c
    ../../../../../Drivers/BSP/Components/vl53l5cx/modules/: vl53l5cx_api.c vl53l5cx_plugin_detection_thresholds.c vl53l5cx_plugin_motion_indicator.c vl53l5cx_plugin_xtalk.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32u5xx_ns.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_cordic.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_fmac.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_hcd.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_irda.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_lptim.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_nand.c stm32u5xx_hal_nor.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_otfdec.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_pssi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_smartcard.c stm32u5xx_hal_smartcard_ex.c stm32u5xx_hal_smbus.c stm32u5xx_hal_smbus_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_wwdg.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_fmc.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32u585xx.s
  group Example/User
    ../NonSecure/Src/: main.c stm32u5xx_hal_msp.c stm32u5xx_it.c
software components: CMSIS:CORE 4.3.0
