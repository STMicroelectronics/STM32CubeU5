# IAR project Demo.ewp, settings and files
configuration STM32U575I-EV (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575AI ST STM32U575AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U575xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Core\Inc; ..\..\Config; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32U575I-EV; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\lpbam\; ..\..\..\..\..\Utilities\lpbam\STM32U5; ..\..\Modules\audio_filtering; ..\..\Modules\calendar; ..\..\Modules\about; ..\..\Modules\main_app; ..\..\Modules\lpbam; ..\..\Modules\low_power; ..\..\Modules\security; ..\..\Modules\cameraviewer; ..\..\Modules\usbpd; ..\..\..\..\..\Utilities\lcd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32CubeU5_Demo_STM32U575I-EV.hex
  ILINK.IlinkOutputFile: STM32U575I-EV_DEMO.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../../Core/Src/: k_demo.c k_menu.c k_module.c k_tools.c k_widgets.c k_window.c
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/Modules/AboutDemo
    ../../Modules/about/: app_about.c
  group Application/Modules/AppMain
    ../../Modules/main_app/: app_main.c
    ../Src/: resources.c
  group Application/Modules/Calendar
    ../../Modules/calendar/: app_calendar.c
  group Application/Modules/CameraViwer
    ../../Modules/cameraviewer/: app_cameraviewer.c
  group Application/Modules/DitigalFiltering
    ../../Modules/audio_filtering/: app_audiofilt.c audio_recplay.c sad.c sig_filtering.c
  group Application/Modules/LowPower
    ../../Modules/low_power/: low_power.c
  group Application/Modules/LPBAM
    ../../Modules/lpbam/: app_lpbam.c sens_acquisition.c signal_gen.c
  group Application/Modules/Security
    ../../Modules/security/: app_security.c control_access.c memory_access.c
  group Application/Modules/USB-PD
    ../../Modules/usbpd/: app_usbpd.c
  group Application/User
    ../Src/: main.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c hx8347i_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../Drivers/BSP/Components/sx8651/: sx8651.c sx8651_reg.c
  group Drivers/BSP/STM32U575I-EV
    ../../../../../Drivers/BSP/STM32U575I-EV/: stm32u575i_eval.c stm32u575i_eval_bus.c stm32u575i_eval_camera.c stm32u575i_eval_io.c stm32u575i_eval_lcd.c stm32u575i_eval_motion_sensors.c stm32u575i_eval_ospi.c stm32u575i_eval_sd.c stm32u575i_eval_sram.c stm32u575i_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Drivers
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_lptim.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_fmc.c stm32u5xx_ll_sdmmc.c
  group Utilities/lcd
    ../../../../../Utilities/lcd/: stm32_lcd.c
  group Utilities/Lpbam
    ../../../../../Utilities/lpbam/: stm32_adv_lpbam_common.c stm32_adv_lpbam_dac.c stm32_adv_lpbam_i2c.c stm32_adv_lpbam_opamp.c stm32_lpbam_common.c stm32_lpbam_dac.c stm32_lpbam_i2c.c stm32_lpbam_opamp.c
    ../../../../../Utilities/lpbam/STM32U5/: stm32_ll_lpbam.c
