<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SD_ReadWrite_DMALinkedList.ewp</path>
  </project>
  <batchBuild />
</workspace>
