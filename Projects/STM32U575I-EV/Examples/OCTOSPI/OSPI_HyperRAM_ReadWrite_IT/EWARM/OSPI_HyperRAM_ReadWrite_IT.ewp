# IAR project OSPI_HyperRAM_ReadWrite_IT.ewp, settings and files
configuration OSPI_HyperRAM_ReadWrite_IT (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575AI ST STM32U575AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/Components/mfxstm32l152; ../../../../../../Drivers/BSP/STM32U575I-EV
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OSPI_HyperRAM_ReadWrite_IT.hex
  ILINK.IlinkOutputFile: OSPI_HyperRAM_ReadWrite_IT.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152_reg.c mfxstm32l152.c
  group Drivers/BSP/STM32U575I-EV
    ../../../../../../Drivers/BSP/STM32U575I-EV/: stm32u575i_eval.c stm32u575i_eval_io.c stm32u575i_eval_bus.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_uart_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_exti.c stm32u5xx_hal_icache.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dcache.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
