<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TSC_BasicAcquisition_Interrupt.ewp</path>
  </project>
  <batchBuild />
</workspace>
