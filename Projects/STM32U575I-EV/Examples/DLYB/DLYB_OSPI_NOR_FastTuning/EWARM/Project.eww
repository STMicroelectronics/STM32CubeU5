<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DLYB_OSPI_NOR_FastTuning.ewp</path>
  </project>
  <batchBuild />
</workspace>
