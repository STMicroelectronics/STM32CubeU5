# Keil uVision project GTZC_MPCWM_IllegalAccess_TrustZone_NS.uvprojx, settings and files
target GTZC_MPCWM_IllegalAccess_TrustZone_NS (6180000::V6.18::ARMCLANG)
  device: STM32U575AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.1
  cpu: IRAM(0x20040000-0x200BFFFF) IROM(0x08100000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: GTZC_MPCWM_IllegalAccess_TrustZone_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../NonSecure/Inc;../Secure_nsclib;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x20040000 size 0x80000
  link misc: ../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/NonSecure
    ../NonSecure/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_sram.c stm32u5xx_ll_fmc.c stm32u5xx_hal_exti.c stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_dcache.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32u5xx_ns.c
software components: CMSIS:CORE 4.3.0
