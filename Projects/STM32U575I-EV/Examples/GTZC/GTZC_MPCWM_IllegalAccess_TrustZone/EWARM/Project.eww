<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\GTZC_MPCWM_IllegalAccess_TrustZone_S.ewp</path>
  </project><project>
    <path>$WS_DIR$\GTZC_MPCWM_IllegalAccess_TrustZone_NS.ewp</path>
  </project>
  <batchBuild />
</workspace>
