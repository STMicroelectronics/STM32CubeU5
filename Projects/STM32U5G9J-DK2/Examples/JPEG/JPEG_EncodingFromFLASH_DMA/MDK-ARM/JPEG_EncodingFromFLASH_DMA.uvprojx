# Keil uVision project JPEG_EncodingFromFLASH_DMA.uvprojx, settings and files
target JPEG_EncodingFromFLASH_DMA (6180000::V6.18::ARMCLANG)
  device: STM32U5G9ZJTxQ STMicroelectronics
  pack: Keil.STM32U5Fx-5Gx_DFP.0.0.1
  cpu: IRAM(0x20000000,0x002F0000) IRAM2(0x24000000,0x01000000) IROM(0x08000000,0x00400000) XRAM(0x28000000,0x00004000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: JPEG_EncodingFromFLASH_DMA +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U5G9xx
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/STM32U5G9J-DK2;../../../../../../Utilities/JPEG
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT6: RAM 0x28000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2f0000
  memory RVCT10: RAM 0x24000000 size 0x1000000
  group Application/MDK-ARM
    ./: startup_stm32u5g9xx.s
  group Application/User
    ..//Src/: encode_dma.c Image_argb_8888.c Image_rgb_565.c Image_rgb_888.c
    ../Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5G9J-DK2
    ../../../../../../Drivers/BSP/STM32U5G9J-DK2/: stm32u5g9j_discovery.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_jpeg.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_icache.c stm32u5xx_hal_gpio.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_exti.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Utilities
    ../../../../../../Utilities/JPEG/: jpeg_utils.c
software components: CMSIS:CORE 4.3.0
