# IAR project JPEG_EncodingFromFLASH_DMA.ewp, settings and files
configuration JPEG_EncodingFromFLASH_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32U5G9ZJ ST STM32U5G9ZJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U5G9xx
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\STM32U5G9J-DK2; ..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\CMSIS\Include; ../Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Utilities/JPEG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: JPEG_EncodingFromFLASH_DMA.hex
  ILINK.IlinkOutputFile: JPEG_EncodingFromFLASH_DMA.out
  ILINK.IlinkIcfFile: stm32u5g9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u5g9xx.s
    ../../../../../../Drivers/BSP/STM32U5G9J-DK2/: stm32u5g9j_discovery.c
  group Application/User
    ../Src/: Image_argb_8888.c Image_rgb_565.c Image_rgb_888.c encode_dma.c main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
    ..//Src/: encode_dma.c Image_argb_8888.c Image_rgb_565.c Image_rgb_888.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U5G9J-DK2
    ../../../../../../Drivers/BSP/STM32U5G9J-DK2/: stm32u5g9j_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_jpeg.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_icache.c stm32u5xx_hal_gpio.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_exti.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Utilities
    ../../../../../../Utilities/JPEG/: jpeg_utils.c
