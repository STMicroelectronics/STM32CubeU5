<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RAMCFG_ECC_Error_Generation.ewp</path>
  </project>
  <batchBuild />
</workspace>
