# Keil uVision project Project.uvprojx, settings and files
target BSP (6180000::V6.18::ARMCLANG)
  device: STM32U5G9ZJTxQ STMicroelectronics
  pack: Keil.STM32U5Fx-5Gx_DFP.0.0.1
  cpu: IRAM(0x20000000,0x002F0000) IRAM2(0x24000000,0x01000000) IROM(0x08000000,0x00400000) XRAM(0x28000000,0x00004000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U5G9xx,USE_FULL_ASSERT,USE_HAL_DRIVER,__TERMINAL_IO__
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32U5G9J-DK2;../../../../../Utilities/lcd;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/vl53l5cx/modules;../../../../../Drivers/BSP/Components/vl53l5cx/porting;../../../../../Drivers/BSP/Components/mx66uw1g45g
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT6: RAM 0x28000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2f0000
  memory RVCT10: RAM 0x24000000 size 0x1000000
  link misc: --diag_suppress=L6329
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
    ../../../../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group Drivers/BSP/STM32U5G9J_DK2
    ../../../../../Drivers/BSP/STM32U5G9J-DK2/: stm32u5g9j_discovery.c stm32u5g9j_discovery_bus.c stm32u5g9j_discovery_hspi.c stm32u5g9j_discovery_lcd.c stm32u5g9j_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_ltdc.c stm32u5xx_hal_ltdc_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c
  group Example/MDK-ARM
    ./: startup_stm32u5g9xx.s
  group Example/User
    ../Src/: button.c hspi_nor.c lcd.c led.c main.c stm32u5xx_it.c touchscreen.c
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
