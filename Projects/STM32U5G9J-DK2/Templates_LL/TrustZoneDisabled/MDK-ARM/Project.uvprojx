# Keil uVision project Project.uvprojx, settings and files
target STM32U5G9J_DK2_Templates_TrustZoneDisabled (6180000::V6.18::ARMCLANG)
  device: STM32U5G9ZJTxQ STMicroelectronics
  pack: Keil.STM32U5Fx-5Gx_DFP.0.0.1
  cpu: IRAM(0x20000000,0x002F0000) IRAM2(0x24000000,0x01000000) IROM(0x08000000,0x00400000) XRAM(0x28000000,0x00004000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: $PROJ_FNAME$ +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U5G9xx,USE_FULL_LL_DRIVER,USE_FULL_ASSERT
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32U5G9J-DK2;../../../../../Drivers/BSP/Components/Common
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT6: RAM 0x28000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2f0000
  memory RVCT10: RAM 0x24000000 size 0x1000000
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_LL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_ll_adc.c stm32u5xx_ll_comp.c stm32u5xx_ll_cordic.c stm32u5xx_ll_crc.c stm32u5xx_ll_crs.c stm32u5xx_ll_dac.c stm32u5xx_ll_dma.c stm32u5xx_ll_dma2d.c stm32u5xx_ll_exti.c stm32u5xx_ll_fmac.c stm32u5xx_ll_gpio.c stm32u5xx_ll_i2c.c stm32u5xx_ll_icache.c stm32u5xx_ll_lpgpio.c stm32u5xx_ll_lptim.c stm32u5xx_ll_lpuart.c stm32u5xx_ll_opamp.c stm32u5xx_ll_pka.c stm32u5xx_ll_pwr.c stm32u5xx_ll_rcc.c stm32u5xx_ll_rng.c stm32u5xx_ll_rtc.c stm32u5xx_ll_spi.c stm32u5xx_ll_tim.c stm32u5xx_ll_ucpd.c stm32u5xx_ll_usart.c stm32u5xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32u5g9xx.s
  group Example/User
    ../Src/: main.c stm32u5xx_it.c
software components: CMSIS:CORE 4.3.0
