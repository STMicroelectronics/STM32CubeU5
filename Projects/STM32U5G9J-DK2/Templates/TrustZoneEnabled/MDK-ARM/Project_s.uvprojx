# Keil uVision project Project_s.uvprojx, settings and files
target STM32U5G9J_DK2_Templates_TrustZoneEnable (6180000::V6.18::ARMCLANG)
  device: STM32U5G9ZJTxQ STMicroelectronics
  pack: Keil.STM32U5Fx-5Gx_DFP.0.0.1
  cpu: IRAM(0x20000000,0x002F0000) IRAM2(0x24000000,0x01000000) IROM(0x08000000,0x00400000) XRAM(0x28000000,0x00004000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project_s +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U5G9xx,USE_HAL_DRIVER
  c include: ../Secure/Inc;../Secure_nsclib;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32U5G9J-DK2;..\..\..\..\..\Drivers\BSP\Components\Common;../../../../../Drivers/BSP/Components/mx66uw1g45g
  memory RVCT4: ROM 0xc000000 size 0xc1fffff
  memory RVCT6: ROM 0x28000000 size 0x4000
  memory RVCT9: RAM 0x30000000 size 0x300cffff
  memory RVCT10: RAM 0x24000000 size 0x1000000
  link misc: --import_cmse_lib_out=../Secure_nsclib/secure_nsclib.o
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32u5xx_s.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_cordic.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dsi.c stm32u5xx_hal_exti.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_fmac.c stm32u5xx_hal_gfxmmu.c stm32u5xx_hal_gfxtim.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_hcd.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_irda.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_jpeg.c stm32u5xx_hal_lptim.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_nand.c stm32u5xx_hal_nor.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_otfdec.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_pssi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_sdio.c stm32u5xx_hal_smartcard.c stm32u5xx_hal_smartcard_ex.c stm32u5xx_hal_smbus.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_wwdg.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_fmc.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32u5g9xx.s
  group Example/User
    ../Secure/Src/: main.c secure_nsc.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
    ../../../../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group Drivers/BSP/STM32U5G9J-DK2
    ../../../../../Drivers/BSP/STM32U5G9J-DK2/: stm32u5g9j_discovery.c stm32u5g9j_discovery_bus.c stm32u5g9j_discovery_hspi.c stm32u5g9j_discovery_lcd.c stm32u5g9j_discovery_ts.c
software components: CMSIS:CORE 4.3.0
